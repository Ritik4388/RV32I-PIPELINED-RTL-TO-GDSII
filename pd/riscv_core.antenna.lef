

# LEF File for Accumulated Process Antenna Effects at the Boundary Pins
# *********************************************************************

VERSION 5.5 ;
NAMESCASESENSITIVE ON ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;

MACRO riscv_core 
  PIN clk 
    ANTENNAPARTIALMETALAREA 74.9732 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 399.84 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.08 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 132.036 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 693.224 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 1.92 LAYER via4 ;
    ANTENNAPARTIALMETALAREA 29.36 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 63.24 LAYER met5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.4175 LAYER met5 ; 
    ANTENNAMAXAREACAR 36.4088 LAYER met5 ;
    ANTENNAMAXSIDEAREACAR 113.463 LAYER met5 ;
  END clk
  PIN rst_n 
    ANTENNAPARTIALMETALAREA 33.6943 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 180.16 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.8505 LAYER met3 ; 
    ANTENNAMAXAREACAR 62.6665 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 323.81 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.26749 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 1.40395 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.832 LAYER met4 ;
    ANTENNAGATEAREA 0.8505 LAYER met4 ; 
    ANTENNAMAXAREACAR 64.3173 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 328.315 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 0.64 LAYER via4 ;
    ANTENNAMAXCUTCAR 1.01999 LAYER via4 ;
    ANTENNAPARTIALMETALAREA 443.056 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 668.424 LAYER met5 ;
    ANTENNAGATEAREA 4.851 LAYER met5 ; 
    ANTENNAMAXAREACAR 155.65 LAYER met5 ;
    ANTENNAMAXSIDEAREACAR 466.106 LAYER met5 ;
  END rst_n
  PIN imem_addr[31] 
    ANTENNAPARTIALMETALAREA 28.8046 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 153.616 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 7.4848 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 36.264 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 0.64 LAYER via4 ;
    ANTENNADIFFAREA 0.5292 LAYER met5 ; 
    ANTENNAPARTIALMETALAREA 411.024 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 624.216 LAYER met5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2835 LAYER met5 ; 
    ANTENNAMAXAREACAR 1531.98 LAYER met5 ;
    ANTENNAMAXSIDEAREACAR 2624.02 LAYER met5 ;
  END imem_addr[31]
  PIN imem_addr[30] 
    ANTENNAPARTIALMETALAREA 1.2656 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 6.167 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 7.3 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 39.4 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 60.6838 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 319.992 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 0.64 LAYER via4 ;
    ANTENNADIFFAREA 2.5292 LAYER met5 ; 
    ANTENNAPARTIALMETALAREA 164.384 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 273.456 LAYER met5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.1655 LAYER met5 ; 
    ANTENNAMAXAREACAR 333.911 LAYER met5 ;
    ANTENNAMAXSIDEAREACAR 1228.1 LAYER met5 ;
  END imem_addr[30]
  PIN imem_addr[29] 
    ANTENNAPARTIALMETALAREA 0.2386 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.264 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 1.6888 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.352 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 0.64 LAYER via4 ;
    ANTENNADIFFAREA 0.5292 LAYER met5 ; 
    ANTENNAPARTIALMETALAREA 645.072 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 975.288 LAYER met5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.9135 LAYER met5 ; 
    ANTENNAMAXAREACAR 781.963 LAYER met5 ;
    ANTENNAMAXSIDEAREACAR 1452.61 LAYER met5 ;
  END imem_addr[29]
  PIN imem_addr[28] 
    ANTENNAPARTIALMETALAREA 25.6996 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 137.056 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 7.7608 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 37.736 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 0.64 LAYER via4 ;
    ANTENNADIFFAREA 3.0584 LAYER met5 ; 
    ANTENNAPARTIALMETALAREA 746.16 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 1153.8 LAYER met5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.9135 LAYER met5 ; 
    ANTENNAMAXAREACAR 993.346 LAYER met5 ;
    ANTENNAMAXSIDEAREACAR 2137.9 LAYER met5 ;
  END imem_addr[28]
  PIN imem_addr[27] 
    ANTENNAPARTIALMETALAREA 20.1106 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 107.248 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 20.4568 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 105.448 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 0.64 LAYER via4 ;
    ANTENNADIFFAREA 0.5292 LAYER met5 ; 
    ANTENNAPARTIALMETALAREA 323.808 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 493.392 LAYER met5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.1655 LAYER met5 ; 
    ANTENNAMAXAREACAR 378.868 LAYER met5 ;
    ANTENNAMAXSIDEAREACAR 953.966 LAYER met5 ;
  END imem_addr[27]
  PIN imem_addr[26] 
    ANTENNAPARTIALMETALAREA 0.8792 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 4.235 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 21.445 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 114.84 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 45.3658 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 238.296 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 0.64 LAYER via4 ;
    ANTENNADIFFAREA 2.5292 LAYER met5 ; 
    ANTENNAPARTIALMETALAREA 219.584 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 356.256 LAYER met5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.1655 LAYER met5 ; 
    ANTENNAMAXAREACAR 301.599 LAYER met5 ;
    ANTENNAMAXSIDEAREACAR 850.516 LAYER met5 ;
  END imem_addr[26]
  PIN imem_addr[25] 
    ANTENNAPARTIALMETALAREA 0.686 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 3.269 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 9.232 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 49.704 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 0.5292 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 139.976 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 743.344 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.441 LAYER met4 ; 
    ANTENNAMAXAREACAR 358.664 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 1895.67 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 0.64 LAYER via4 ;
    ANTENNAMAXCUTCAR 2.10204 LAYER via4 ;
    ANTENNADIFFAREA 0.5292 LAYER met5 ; 
    ANTENNAPARTIALMETALAREA 114.064 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 174.936 LAYER met5 ;
    ANTENNAGATEAREA 1.1655 LAYER met5 ; 
    ANTENNAMAXAREACAR 456.531 LAYER met5 ;
    ANTENNAMAXSIDEAREACAR 2045.77 LAYER met5 ;
  END imem_addr[25]
  PIN imem_addr[24] 
    ANTENNAPARTIALMETALAREA 21.5596 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 114.976 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 2.9998 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.344 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 0.64 LAYER via4 ;
    ANTENNADIFFAREA 0.5292 LAYER met5 ; 
    ANTENNAPARTIALMETALAREA 439.744 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 663.456 LAYER met5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2835 LAYER met5 ; 
    ANTENNAMAXAREACAR 1580.71 LAYER met5 ;
    ANTENNAMAXSIDEAREACAR 2481.42 LAYER met5 ;
  END imem_addr[24]
  PIN imem_addr[23] 
    ANTENNAPARTIALMETALAREA 0.4928 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.303 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 11.509 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 61.848 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 0.5292 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 130.592 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 694.248 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.441 LAYER met4 ; 
    ANTENNAMAXAREACAR 349.301 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 1848.9 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 0.64 LAYER via4 ;
    ANTENNAMAXCUTCAR 2.60998 LAYER via4 ;
    ANTENNADIFFAREA 2.5292 LAYER met5 ; 
    ANTENNAPARTIALMETALAREA 91.232 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 144.528 LAYER met5 ;
    ANTENNAGATEAREA 1.1655 LAYER met5 ; 
    ANTENNAMAXAREACAR 427.578 LAYER met5 ;
    ANTENNAMAXSIDEAREACAR 1972.9 LAYER met5 ;
  END imem_addr[23]
  PIN imem_addr[22] 
    ANTENNAPARTIALMETALAREA 1.0724 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 5.201 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 3.091 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 16.952 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 0.5292 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 111.095 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 592.968 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.1655 LAYER met4 ; 
    ANTENNAMAXAREACAR 172.123 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 896.663 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via4 ;
  END imem_addr[22]
  PIN imem_addr[21] 
    ANTENNAPARTIALMETALAREA 2.1994 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 10.836 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 9.793 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 52.696 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 0.5292 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 93.8016 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 501.216 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.1655 LAYER met4 ; 
    ANTENNAMAXAREACAR 164.327 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 855.615 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.8322 LAYER via4 ;
  END imem_addr[21]
  PIN imem_addr[20] 
    ANTENNAPARTIALMETALAREA 7.1582 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 35.63 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 2.332 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.904 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 0.5292 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 101.927 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 540.424 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.441 LAYER met4 ; 
    ANTENNAMAXAREACAR 306.984 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 1625.9 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 0.64 LAYER via4 ;
    ANTENNAMAXCUTCAR 2.10204 LAYER via4 ;
    ANTENNADIFFAREA 0.5292 LAYER met5 ; 
    ANTENNAPARTIALMETALAREA 136.144 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 208.056 LAYER met5 ;
    ANTENNAGATEAREA 0.9135 LAYER met5 ; 
    ANTENNAMAXAREACAR 456.019 LAYER met5 ;
    ANTENNAMAXSIDEAREACAR 1853.66 LAYER met5 ;
  END imem_addr[20]
  PIN imem_addr[19] 
    ANTENNAPARTIALMETALAREA 0.1127 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4025 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 8.473 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 45.656 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 0.5292 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 114.002 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 604.824 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.441 LAYER met4 ; 
    ANTENNAMAXAREACAR 311.928 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 1655.74 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 0.64 LAYER via4 ;
    ANTENNAMAXCUTCAR 2.10204 LAYER via4 ;
    ANTENNADIFFAREA 0.5292 LAYER met5 ; 
    ANTENNAPARTIALMETALAREA 72.112 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 112.008 LAYER met5 ;
    ANTENNAGATEAREA 1.1655 LAYER met5 ; 
    ANTENNAMAXAREACAR 373.8 LAYER met5 ;
    ANTENNAMAXSIDEAREACAR 1751.85 LAYER met5 ;
  END imem_addr[19]
  PIN imem_addr[18] 
    ANTENNAPARTIALMETALAREA 9.7664 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 48.671 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 6.886 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 37.192 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 57.1648 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 301.224 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 0.64 LAYER via4 ;
    ANTENNADIFFAREA 0.5292 LAYER met5 ; 
    ANTENNAPARTIALMETALAREA 121.792 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 186.528 LAYER met5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.1655 LAYER met5 ; 
    ANTENNAMAXAREACAR 209.869 LAYER met5 ;
    ANTENNAMAXSIDEAREACAR 697.394 LAYER met5 ;
  END imem_addr[18]
  PIN imem_addr[17] 
    ANTENNAPARTIALMETALAREA 1.3622 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 6.65 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 8.059 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 43.448 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 90.8368 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 480.808 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 0.64 LAYER via4 ;
    ANTENNADIFFAREA 0.5292 LAYER met5 ; 
    ANTENNAPARTIALMETALAREA 51.504 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 81.096 LAYER met5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.1655 LAYER met5 ; 
    ANTENNAMAXAREACAR 132.083 LAYER met5 ;
    ANTENNAMAXSIDEAREACAR 520.279 LAYER met5 ;
  END imem_addr[17]
  PIN imem_addr[16] 
    ANTENNAPARTIALMETALAREA 4.1314 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 20.496 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 3.919 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 21.368 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 101.254 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 540.96 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.882 LAYER met4 ; 
    ANTENNAMAXAREACAR 140.108 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 737.115 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.502646 LAYER via4 ;
  END imem_addr[16]
  PIN imem_addr[15] 
    ANTENNAPARTIALMETALAREA 7.287 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 36.274 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 5.299 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 28.728 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 0.5292 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 111.081 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 592.896 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.1655 LAYER met4 ; 
    ANTENNAMAXAREACAR 155.609 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 826.023 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.442177 LAYER via4 ;
  END imem_addr[15]
  PIN imem_addr[14] 
    ANTENNAPARTIALMETALAREA 0.686 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 3.269 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 14.269 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 76.568 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 0.5292 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 126.331 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 675.648 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.1655 LAYER met4 ; 
    ANTENNAMAXAREACAR 179.706 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 946.21 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via4 ;
  END imem_addr[14]
  PIN imem_addr[13] 
    ANTENNAPARTIALMETALAREA 25.4926 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 135.952 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 7.1398 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 34.424 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 0.64 LAYER via4 ;
    ANTENNADIFFAREA 0.5292 LAYER met5 ; 
    ANTENNAPARTIALMETALAREA 416.912 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 633.048 LAYER met5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.5985 LAYER met5 ; 
    ANTENNAMAXAREACAR 777.757 LAYER met5 ;
    ANTENNAMAXSIDEAREACAR 1465.45 LAYER met5 ;
  END imem_addr[13]
  PIN imem_addr[12] 
    ANTENNAPARTIALMETALAREA 1.2397 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 6.0375 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 20.134 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 107.848 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 0.5292 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 122.588 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 650.608 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.441 LAYER met4 ; 
    ANTENNAMAXAREACAR 305.064 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 1613.53 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 0.64 LAYER via4 ;
    ANTENNAMAXCUTCAR 2.10204 LAYER via4 ;
    ANTENNADIFFAREA 0.5292 LAYER met5 ; 
    ANTENNAPARTIALMETALAREA 227.04 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 344.4 LAYER met5 ;
    ANTENNAGATEAREA 1.1655 LAYER met5 ; 
    ANTENNAMAXAREACAR 499.865 LAYER met5 ;
    ANTENNAMAXSIDEAREACAR 1909.03 LAYER met5 ;
  END imem_addr[12]
  PIN imem_addr[11] 
    ANTENNAPARTIALMETALAREA 2.3282 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 11.48 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 14.062 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 75.464 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 0.5292 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 111.734 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 592.728 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.441 LAYER met4 ; 
    ANTENNAMAXAREACAR 362.413 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 1923.56 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 0.64 LAYER via4 ;
    ANTENNAMAXCUTCAR 2.35601 LAYER via4 ;
    ANTENNADIFFAREA 0.5292 LAYER met5 ; 
    ANTENNAPARTIALMETALAREA 80.944 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 125.256 LAYER met5 ;
    ANTENNAGATEAREA 0.9135 LAYER met5 ; 
    ANTENNAMAXAREACAR 451.022 LAYER met5 ;
    ANTENNAMAXSIDEAREACAR 2060.68 LAYER met5 ;
  END imem_addr[11]
  PIN imem_addr[10] 
    ANTENNAPARTIALMETALAREA 5.6448 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 28.063 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 20.479 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 109.688 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 67.0318 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 353.848 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 0.64 LAYER via4 ;
    ANTENNADIFFAREA 0.5292 LAYER met5 ; 
    ANTENNAPARTIALMETALAREA 246.912 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 374.208 LAYER met5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.1655 LAYER met5 ; 
    ANTENNAMAXAREACAR 301.936 LAYER met5 ;
    ANTENNAMAXSIDEAREACAR 787.538 LAYER met5 ;
  END imem_addr[10]
  PIN imem_addr[9] 
    ANTENNAPARTIALMETALAREA 39.5686 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 211.024 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 12.7978 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 64.6 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 0.64 LAYER via4 ;
    ANTENNADIFFAREA 0.5292 LAYER met5 ; 
    ANTENNAPARTIALMETALAREA 369.088 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 557.472 LAYER met5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.9135 LAYER met5 ; 
    ANTENNAMAXAREACAR 479.233 LAYER met5 ;
    ANTENNAMAXSIDEAREACAR 992.562 LAYER met5 ;
  END imem_addr[9]
  PIN imem_addr[8] 
    ANTENNAPARTIALMETALAREA 0.2996 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.337 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.745 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.44 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 62.6656 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 331.032 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 0.64 LAYER via4 ;
    ANTENNADIFFAREA 2.5292 LAYER met5 ; 
    ANTENNAPARTIALMETALAREA 300.528 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 481.512 LAYER met5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.1655 LAYER met5 ; 
    ANTENNAMAXAREACAR 330.989 LAYER met5 ;
    ANTENNAMAXSIDEAREACAR 768.005 LAYER met5 ;
  END imem_addr[8]
  PIN imem_addr[7] 
    ANTENNAPARTIALMETALAREA 0.5894 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.786 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.952 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.544 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 101.601 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 538.216 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 0.64 LAYER via4 ;
    ANTENNADIFFAREA 1.0584 LAYER met5 ; 
    ANTENNAPARTIALMETALAREA 40.096 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 63.984 LAYER met5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.583 LAYER met5 ; 
    ANTENNAMAXAREACAR 88.1829 LAYER met5 ;
    ANTENNAMAXSIDEAREACAR 407.007 LAYER met5 ;
  END imem_addr[7]
  PIN imem_addr[6] 
    ANTENNAPARTIALMETALAREA 1.0666 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.68 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 4.7248 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 21.544 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 0.64 LAYER via4 ;
    ANTENNADIFFAREA 0.5292 LAYER met5 ; 
    ANTENNAPARTIALMETALAREA 635.84 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 969.12 LAYER met5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.756 LAYER met5 ; 
    ANTENNAMAXAREACAR 958.74 LAYER met5 ;
    ANTENNAMAXSIDEAREACAR 1879.71 LAYER met5 ;
  END imem_addr[6]
  PIN imem_addr[5] 
    ANTENNAPARTIALMETALAREA 1.3622 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 6.65 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 8.404 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 45.288 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 0.5292 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 121.57 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 650.256 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.6065 LAYER met4 ; 
    ANTENNAMAXAREACAR 104.549 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 556.693 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.904762 LAYER via4 ;
  END imem_addr[5]
  PIN imem_addr[4] 
    ANTENNAPARTIALMETALAREA 1.6842 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 8.26 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 13.717 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 73.624 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 0.5292 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 104.566 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 558.624 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.89 LAYER met4 ; 
    ANTENNAMAXAREACAR 99.4386 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 515.839 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.700591 LAYER via4 ;
  END imem_addr[4]
  PIN imem_addr[3] 
    ANTENNAPARTIALMETALAREA 1.652 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 8.099 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.469 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.968 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 0.5292 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 135.202 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 722.016 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.54425 LAYER met4 ; 
    ANTENNAMAXAREACAR 150.357 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 797.066 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.904762 LAYER via4 ;
  END imem_addr[3]
  PIN imem_addr[2] 
    ANTENNAPARTIALMETALAREA 28.3906 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 151.408 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 3.8968 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 17.128 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 0.64 LAYER via4 ;
    ANTENNADIFFAREA 0.5292 LAYER met5 ; 
    ANTENNAPARTIALMETALAREA 486.08 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 740.64 LAYER met5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.756 LAYER met5 ; 
    ANTENNAMAXAREACAR 839.936 LAYER met5 ;
    ANTENNAMAXSIDEAREACAR 2003.09 LAYER met5 ;
  END imem_addr[2]
  PIN imem_addr[1] 
    ANTENNAPARTIALMETALAREA 19.5466 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 104.24 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 7.3468 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 35.528 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 0.64 LAYER via4 ;
    ANTENNADIFFAREA 0.5292 LAYER met5 ; 
    ANTENNAPARTIALMETALAREA 257.584 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 390.216 LAYER met5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.5985 LAYER met5 ; 
    ANTENNAMAXAREACAR 559.43 LAYER met5 ;
    ANTENNAMAXSIDEAREACAR 1322.69 LAYER met5 ;
  END imem_addr[1]
  PIN imem_addr[0] 
    ANTENNAPARTIALMETALAREA 19.0756 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 101.728 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 5.2078 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 24.12 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 0.64 LAYER via4 ;
    ANTENNADIFFAREA 0.5292 LAYER met5 ; 
    ANTENNAPARTIALMETALAREA 498.256 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 751.224 LAYER met5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.5985 LAYER met5 ; 
    ANTENNAMAXAREACAR 904.636 LAYER met5 ;
    ANTENNAMAXSIDEAREACAR 1627.5 LAYER met5 ;
  END imem_addr[0]
  PIN imem_rdata[31] 
    ANTENNAPARTIALMETALAREA 6.7074 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 33.376 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 3.2928 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 18.032 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met3 ; 
    ANTENNAMAXAREACAR 56.7105 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 285.241 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END imem_rdata[31]
  PIN imem_rdata[30] 
    ANTENNAPARTIALMETALAREA 2.7468 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 13.573 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 1.8936 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 11.04 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met3 ; 
    ANTENNAMAXAREACAR 26.1556 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 132.492 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END imem_rdata[30]
  PIN imem_rdata[29] 
    ANTENNAPARTIALMETALAREA 8.6514 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 46.136 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met3 ; 
    ANTENNAMAXAREACAR 67.2222 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 346.124 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END imem_rdata[29]
  PIN imem_rdata[28] 
    ANTENNAPARTIALMETALAREA 5.2014 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 27.736 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met3 ; 
    ANTENNAMAXAREACAR 44.4997 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 225.21 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END imem_rdata[28]
  PIN imem_rdata[27] 
    ANTENNAPARTIALMETALAREA 4.6494 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 24.792 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met3 ; 
    ANTENNAMAXAREACAR 47.946 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 241.273 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END imem_rdata[27]
  PIN imem_rdata[26] 
    ANTENNAPARTIALMETALAREA 4.9254 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 26.264 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met3 ; 
    ANTENNAMAXAREACAR 43.5917 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 220.086 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END imem_rdata[26]
  PIN imem_rdata[25] 
    ANTENNAPARTIALMETALAREA 7.2548 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 36.113 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 5.0868 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 27.6 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met3 ; 
    ANTENNAMAXAREACAR 69.5587 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 353.279 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END imem_rdata[25]
  PIN imem_rdata[24] 
    ANTENNAPARTIALMETALAREA 0.7826 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 3.752 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 3.298 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 18.056 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 9.1408 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 45.096 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 0.64 LAYER via4 ;
    ANTENNAPARTIALMETALAREA 22.784 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 41.856 LAYER met5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met5 ; 
    ANTENNAMAXAREACAR 184.964 LAYER met5 ;
    ANTENNAMAXSIDEAREACAR 450.486 LAYER met5 ;
  END imem_rdata[24]
  PIN imem_rdata[23] 
    ANTENNAPARTIALMETALAREA 5.9346 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 29.512 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 6.3288 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 34.224 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met3 ; 
    ANTENNAMAXAREACAR 83.3467 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 424.848 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END imem_rdata[23]
  PIN imem_rdata[22] 
    ANTENNAPARTIALMETALAREA 1.2012 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 5.845 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 5.0868 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 27.6 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met3 ; 
    ANTENNAMAXAREACAR 105.514 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 533.057 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END imem_rdata[22]
  PIN imem_rdata[21] 
    ANTENNAPARTIALMETALAREA 0.203 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.854 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 2.47 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 13.64 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 13.9018 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 70.488 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 0.64 LAYER via4 ;
    ANTENNAPARTIALMETALAREA 14.32 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 29.16 LAYER met5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met5 ; 
    ANTENNAMAXAREACAR 127.25 LAYER met5 ;
    ANTENNAMAXSIDEAREACAR 349.813 LAYER met5 ;
  END imem_rdata[21]
  PIN imem_rdata[20] 
    ANTENNAPARTIALMETALAREA 3.1332 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 15.505 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 5.368 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 29.096 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 8.6578 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 42.52 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 0.64 LAYER via4 ;
    ANTENNAPARTIALMETALAREA 11.744 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 25.296 LAYER met5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met5 ; 
    ANTENNAMAXAREACAR 107.789 LAYER met5 ;
    ANTENNAMAXSIDEAREACAR 307.603 LAYER met5 ;
  END imem_rdata[20]
  PIN imem_rdata[19] 
    ANTENNAPARTIALMETALAREA 3.0366 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 15.022 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 3.9636 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 22.08 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met3 ; 
    ANTENNAMAXAREACAR 28.9568 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 151.565 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END imem_rdata[19]
  PIN imem_rdata[18] 
    ANTENNAPARTIALMETALAREA 7.3764 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 36.603 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 7.2258 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 39.008 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met3 ; 
    ANTENNAMAXAREACAR 50.6463 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 263.244 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END imem_rdata[18]
  PIN imem_rdata[17] 
    ANTENNAPARTIALMETALAREA 2.2638 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 11.158 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 3.367 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 18.424 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 3.8448 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 20.976 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met4 ; 
    ANTENNAMAXAREACAR 32.2927 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 168.473 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via4 ;
  END imem_rdata[17]
  PIN imem_rdata[16] 
    ANTENNAPARTIALMETALAREA 5.219 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 25.816 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.3948 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.576 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met3 ; 
    ANTENNAMAXAREACAR 10.1371 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 46.2413 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END imem_rdata[16]
  PIN imem_rdata[15] 
    ANTENNAPARTIALMETALAREA 1.7486 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 8.582 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.6708 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.048 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met3 ; 
    ANTENNAMAXAREACAR 55.1917 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 272.098 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END imem_rdata[15]
  PIN imem_rdata[14] 
    ANTENNAPARTIALMETALAREA 1.6842 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 8.26 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 4.264 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 23.208 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 17.1448 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 87.784 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 0.64 LAYER via4 ;
    ANTENNAPARTIALMETALAREA 14.688 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 29.712 LAYER met5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met5 ; 
    ANTENNAMAXAREACAR 129.005 LAYER met5 ;
    ANTENNAMAXSIDEAREACAR 348.263 LAYER met5 ;
  END imem_rdata[14]
  PIN imem_rdata[13] 
    ANTENNAPARTIALMETALAREA 10.5545 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 52.6645 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met2 ; 
    ANTENNAMAXAREACAR 70.0438 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 342.352 LAYER met2 ;
    ANTENNAMAXCUTCAR 0.142857 LAYER via2 ;
  END imem_rdata[13]
  PIN imem_rdata[12] 
    ANTENNAPARTIALMETALAREA 10.8121 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 53.9525 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met2 ; 
    ANTENNAMAXAREACAR 71.6794 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 350.53 LAYER met2 ;
    ANTENNAMAXCUTCAR 0.142857 LAYER via2 ;
  END imem_rdata[12]
  PIN imem_rdata[11] 
    ANTENNAPARTIALMETALAREA 5.0652 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 25.165 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.6708 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.048 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met3 ; 
    ANTENNAMAXAREACAR 8.28635 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 37.4762 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END imem_rdata[11]
  PIN imem_rdata[10] 
    ANTENNAPARTIALMETALAREA 1.9893 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 9.8385 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met2 ; 
    ANTENNAMAXAREACAR 15.6616 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 70.4413 LAYER met2 ;
    ANTENNAMAXCUTCAR 0.142857 LAYER via2 ;
  END imem_rdata[10]
  PIN imem_rdata[9] 
    ANTENNAPARTIALMETALAREA 2.6824 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 13.251 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.5328 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.312 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met3 ; 
    ANTENNAMAXAREACAR 7.41016 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 32.8032 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END imem_rdata[9]
  PIN imem_rdata[8] 
    ANTENNAPARTIALMETALAREA 10.2253 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 50.9005 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met2 ; 
    ANTENNAMAXAREACAR 67.9537 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 331.152 LAYER met2 ;
    ANTENNAMAXCUTCAR 0.142857 LAYER via2 ;
  END imem_rdata[8]
  PIN imem_rdata[7] 
    ANTENNAPARTIALMETALAREA 4.5623 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 22.5855 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met2 ; 
    ANTENNAMAXAREACAR 31.9981 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 151.375 LAYER met2 ;
    ANTENNAMAXCUTCAR 0.142857 LAYER via2 ;
  END imem_rdata[7]
  PIN imem_rdata[6] 
    ANTENNAPARTIALMETALAREA 1.974 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 9.709 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 2.8788 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.824 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met3 ; 
    ANTENNAMAXAREACAR 77.454 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 388.863 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END imem_rdata[6]
  PIN imem_rdata[5] 
    ANTENNAPARTIALMETALAREA 7.0644 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 37.672 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met4 ; 
    ANTENNAMAXAREACAR 100.161 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 520.098 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via4 ;
  END imem_rdata[5]
  PIN imem_rdata[4] 
    ANTENNAPARTIALMETALAREA 5.7817 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 28.6825 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met2 ; 
    ANTENNAMAXAREACAR 39.4165 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 189.705 LAYER met2 ;
    ANTENNAMAXCUTCAR 0.142857 LAYER via2 ;
  END imem_rdata[4]
  PIN imem_rdata[3] 
    ANTENNAPARTIALMETALAREA 5.7736 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 28.707 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.9468 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.52 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met3 ; 
    ANTENNAMAXAREACAR 10.5352 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 49.4 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END imem_rdata[3]
  PIN imem_rdata[2] 
    ANTENNAPARTIALMETALAREA 11.0964 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 54.464 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 0.64 LAYER via4 ;
    ANTENNAPARTIALMETALAREA 15.424 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 30.816 LAYER met5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met5 ; 
    ANTENNAMAXAREACAR 120.416 LAYER met5 ;
    ANTENNAMAXSIDEAREACAR 286.841 LAYER met5 ;
  END imem_rdata[2]
  PIN imem_rdata[1] 
    ANTENNAPARTIALMETALAREA 0.203 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.854 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.883 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.176 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 8.8128 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 47.472 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met4 ; 
    ANTENNAMAXAREACAR 61.847 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 326.956 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via4 ;
  END imem_rdata[1]
  PIN imem_rdata[0] 
    ANTENNAPARTIALMETALAREA 0.1127 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4025 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 1.0848 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.256 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met3 ; 
    ANTENNAMAXAREACAR 30.6292 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 150.162 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END imem_rdata[0]
  PIN dmem_req 
    ANTENNADIFFAREA 0.5292 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 17.4144 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 92.872 LAYER met4 ;
  END dmem_req
  PIN dmem_we 
    ANTENNADIFFAREA 0.5292 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 20.5194 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 109.432 LAYER met4 ;
  END dmem_we
  PIN dmem_addr[31] 
    ANTENNAPARTIALMETALAREA 0.3962 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.82 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.883 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.176 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 2.5292 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 15.498 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 85.008 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met4 ; 
    ANTENNAMAXAREACAR 202.949 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 1081.18 LAYER met4 ;
    ANTENNAMAXCUTCAR 1.15873 LAYER via4 ;
  END dmem_addr[31]
  PIN dmem_addr[30] 
    ANTENNAPARTIALMETALAREA 1.008 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 4.879 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 7.369 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 39.768 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 0.5292 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 7.9848 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 43.056 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met4 ; 
    ANTENNAMAXAREACAR 101.039 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 535.495 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via4 ;
  END dmem_addr[30]
  PIN dmem_addr[29] 
    ANTENNAPARTIALMETALAREA 0.2996 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.337 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 9.715 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 52.28 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 0.5292 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 12.3318 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 66.24 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met4 ; 
    ANTENNAMAXAREACAR 154.493 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 807.438 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via4 ;
  END dmem_addr[29]
  PIN dmem_addr[28] 
    ANTENNADIFFAREA 0.5292 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 12.1313 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 60.3225 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met2 ; 
    ANTENNAMAXAREACAR 82.6095 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 403.66 LAYER met2 ;
    ANTENNAMAXCUTCAR 0.142857 LAYER via2 ;
  END dmem_addr[28]
  PIN dmem_addr[27] 
    ANTENNAPARTIALMETALAREA 0.1127 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4025 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.5292 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 18.3156 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 98.624 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met3 ; 
    ANTENNAMAXAREACAR 192.241 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 997.022 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via3 ;
  END dmem_addr[27]
  PIN dmem_addr[26] 
    ANTENNAPARTIALMETALAREA 4.9542 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 24.374 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met2 ; 
    ANTENNAMAXAREACAR 36.2229 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 171.327 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.4 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.6 LAYER met3 ;
    ANTENNAGATEAREA 0.1575 LAYER met3 ; 
    ANTENNAMAXAREACAR 38.7625 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 187.835 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via3 ;
    ANTENNADIFFAREA 0.5292 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 40.0698 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 214.176 LAYER met4 ;
    ANTENNAGATEAREA 0.1575 LAYER met4 ; 
    ANTENNAMAXAREACAR 293.174 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 1547.68 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via4 ;
  END dmem_addr[26]
  PIN dmem_addr[25] 
    ANTENNAPARTIALMETALAREA 1.974 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 9.709 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 3.9904 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 21.744 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met3 ; 
    ANTENNAMAXAREACAR 31.3981 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 160.473 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via3 ;
    ANTENNADIFFAREA 0.5292 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 47.3148 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 252.816 LAYER met4 ;
    ANTENNAGATEAREA 0.441 LAYER met4 ; 
    ANTENNAMAXAREACAR 138.688 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 733.752 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via4 ;
  END dmem_addr[25]
  PIN dmem_addr[24] 
    ANTENNADIFFAREA 0.5292 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 25.7841 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 128.587 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met2 ; 
    ANTENNAMAXAREACAR 168.476 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 832.994 LAYER met2 ;
    ANTENNAMAXCUTCAR 0.142857 LAYER via2 ;
  END dmem_addr[24]
  PIN dmem_addr[23] 
    ANTENNAPARTIALMETALAREA 1.8774 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 9.226 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 2.3818 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 13.64 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 0.5292 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 18.7893 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 101.616 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.441 LAYER met4 ; 
    ANTENNAMAXAREACAR 60.8571 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 324.036 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via4 ;
  END dmem_addr[23]
  PIN dmem_addr[22] 
    ANTENNAPARTIALMETALAREA 3.584 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 17.759 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 13.234 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 71.048 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 0.5292 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 21.7656 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 117.024 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met4 ; 
    ANTENNAMAXAREACAR 173 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 923.108 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.904762 LAYER via4 ;
  END dmem_addr[22]
  PIN dmem_addr[21] 
    ANTENNAPARTIALMETALAREA 2.2888 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 11.165 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.5292 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 4.6536 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 25.76 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met3 ; 
    ANTENNAMAXAREACAR 89.6311 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 455.06 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via3 ;
  END dmem_addr[21]
  PIN dmem_addr[20] 
    ANTENNAPARTIALMETALAREA 2.6779 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 13.0025 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met2 ; 
    ANTENNAMAXAREACAR 19.9365 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 90.4159 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.676 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.072 LAYER met3 ;
    ANTENNAGATEAREA 0.1575 LAYER met3 ; 
    ANTENNAMAXAREACAR 24.2286 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 116.27 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via3 ;
    ANTENNADIFFAREA 0.5292 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 36.5508 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 195.408 LAYER met4 ;
    ANTENNAGATEAREA 0.1575 LAYER met4 ; 
    ANTENNAMAXAREACAR 256.297 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 1356.96 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via4 ;
  END dmem_addr[20]
  PIN dmem_addr[19] 
    ANTENNAPARTIALMETALAREA 0.4928 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.303 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 21.514 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 115.208 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 0.5292 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 33.6627 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 180 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met4 ; 
    ANTENNAMAXAREACAR 227.211 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 1208.41 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via4 ;
  END dmem_addr[19]
  PIN dmem_addr[18] 
    ANTENNADIFFAREA 0.5292 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 12.3931 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 61.6315 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met2 ; 
    ANTENNAMAXAREACAR 81.6203 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 399.171 LAYER met2 ;
    ANTENNAMAXCUTCAR 0.142857 LAYER via2 ;
  END dmem_addr[18]
  PIN dmem_addr[17] 
    ANTENNAPARTIALMETALAREA 2.135 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 10.514 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 8.8279 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 47.544 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met3 ; 
    ANTENNAMAXAREACAR 66.6038 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 346.283 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via3 ;
    ANTENNADIFFAREA 0.5292 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 49.5918 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 264.96 LAYER met4 ;
    ANTENNAGATEAREA 0.441 LAYER met4 ; 
    ANTENNAMAXAREACAR 179.057 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 947.099 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via4 ;
  END dmem_addr[17]
  PIN dmem_addr[16] 
    ANTENNAPARTIALMETALAREA 0.203 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.854 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 5.851 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 31.672 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 0.5292 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 26.7336 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 143.52 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.7245 LAYER met4 ; 
    ANTENNAMAXAREACAR 95.9889 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 506.848 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.904762 LAYER via4 ;
  END dmem_addr[16]
  PIN dmem_addr[15] 
    ANTENNADIFFAREA 0.5292 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 18.3612 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 98.392 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.441 LAYER met4 ; 
    ANTENNAMAXAREACAR 112.192 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 579.252 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.487528 LAYER via4 ;
  END dmem_addr[15]
  PIN dmem_addr[14] 
    ANTENNAPARTIALMETALAREA 4.71 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 23.163 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met2 ; 
    ANTENNAMAXAREACAR 36.3079 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 171.816 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 1.159 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.648 LAYER met3 ;
    ANTENNAGATEAREA 0.1575 LAYER met3 ; 
    ANTENNAMAXAREACAR 43.6667 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 214.025 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via3 ;
    ANTENNADIFFAREA 0.5292 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 38.8278 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 207.552 LAYER met4 ;
    ANTENNAGATEAREA 0.1575 LAYER met4 ; 
    ANTENNAMAXAREACAR 290.192 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 1531.82 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via4 ;
  END dmem_addr[14]
  PIN dmem_addr[13] 
    ANTENNAPARTIALMETALAREA 3.2942 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 16.31 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 2.2729 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.584 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met3 ; 
    ANTENNAMAXAREACAR 18.1251 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 91.1587 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via3 ;
    ANTENNADIFFAREA 0.5292 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 42.9984 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 230.736 LAYER met4 ;
    ANTENNAGATEAREA 0.441 LAYER met4 ; 
    ANTENNAMAXAREACAR 115.627 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 614.37 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via4 ;
  END dmem_addr[13]
  PIN dmem_addr[12] 
    ANTENNAPARTIALMETALAREA 3.9372 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 19.299 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met2 ; 
    ANTENNAMAXAREACAR 27.9321 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 130.394 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 3.781 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 20.632 LAYER met3 ;
    ANTENNAGATEAREA 0.1575 LAYER met3 ; 
    ANTENNAMAXAREACAR 51.9384 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 261.39 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 2.7238 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 10.872 LAYER met4 ;
    ANTENNAGATEAREA 0.1575 LAYER met4 ; 
    ANTENNAMAXAREACAR 69.2324 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 330.419 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 0.64 LAYER via4 ;
    ANTENNAMAXCUTCAR 4.71429 LAYER via4 ;
    ANTENNADIFFAREA 0.5292 LAYER met5 ; 
    ANTENNAPARTIALMETALAREA 93.792 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 152.208 LAYER met5 ;
    ANTENNAGATEAREA 0.441 LAYER met5 ; 
    ANTENNAMAXAREACAR 338.65 LAYER met5 ;
    ANTENNAMAXSIDEAREACAR 1000.37 LAYER met5 ;
  END dmem_addr[12]
  PIN dmem_addr[11] 
    ANTENNAPARTIALMETALAREA 3.5196 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 17.437 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 6.9626 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 37.592 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.08 LAYER via3 ;
    ANTENNADIFFAREA 0.5292 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 76.149 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 408.48 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.441 LAYER met4 ; 
    ANTENNAMAXAREACAR 187.467 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 998.478 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via4 ;
  END dmem_addr[11]
  PIN dmem_addr[10] 
    ANTENNAPARTIALMETALAREA 2.5214 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 12.446 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 9.7747 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 53.064 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met3 ; 
    ANTENNAMAXAREACAR 66.6927 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 352.175 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via3 ;
    ANTENNADIFFAREA 0.5292 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 51.1596 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 273.792 LAYER met4 ;
    ANTENNAGATEAREA 0.441 LAYER met4 ; 
    ANTENNAMAXAREACAR 182.701 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 973.018 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via4 ;
  END dmem_addr[10]
  PIN dmem_addr[9] 
    ANTENNAPARTIALMETALAREA 2.0384 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 10.031 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 11.6278 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 62.952 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met3 ; 
    ANTENNAMAXAREACAR 84.7721 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 445.044 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.904762 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 2.3404 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.768 LAYER met4 ;
    ANTENNAGATEAREA 0.1575 LAYER met4 ; 
    ANTENNAMAXAREACAR 99.6317 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 507.063 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 0.64 LAYER via4 ;
    ANTENNAMAXCUTCAR 4.96825 LAYER via4 ;
    ANTENNADIFFAREA 0.5292 LAYER met5 ; 
    ANTENNAPARTIALMETALAREA 88.272 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 143.928 LAYER met5 ;
    ANTENNAGATEAREA 0.441 LAYER met5 ; 
    ANTENNAMAXAREACAR 299.795 LAYER met5 ;
    ANTENNAMAXSIDEAREACAR 833.431 LAYER met5 ;
  END dmem_addr[9]
  PIN dmem_addr[8] 
    ANTENNAPARTIALMETALAREA 3.3264 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 16.471 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 2.5198 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 14.376 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met3 ; 
    ANTENNAMAXAREACAR 37.3568 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 188.692 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.904762 LAYER via3 ;
    ANTENNADIFFAREA 0.5292 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 69.3756 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 370.944 LAYER met4 ;
    ANTENNAGATEAREA 0.441 LAYER met4 ; 
    ANTENNAMAXAREACAR 194.671 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 1029.83 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.904762 LAYER via4 ;
  END dmem_addr[8]
  PIN dmem_addr[7] 
    ANTENNAPARTIALMETALAREA 5.4838 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 27.258 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 9.3034 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 50.08 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met3 ; 
    ANTENNAMAXAREACAR 67.5784 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 352.162 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via3 ;
    ANTENNADIFFAREA 0.5292 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 6.5358 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 35.328 LAYER met4 ;
    ANTENNAGATEAREA 0.1575 LAYER met4 ; 
    ANTENNAMAXAREACAR 109.076 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 576.467 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via4 ;
  END dmem_addr[7]
  PIN dmem_addr[6] 
    ANTENNAPARTIALMETALAREA 6.5174 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 32.2 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met2 ; 
    ANTENNAMAXAREACAR 44.3143 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 212.305 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.469 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.968 LAYER met3 ;
    ANTENNAGATEAREA 0.1575 LAYER met3 ; 
    ANTENNAMAXAREACAR 47.2921 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 231.149 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via3 ;
    ANTENNADIFFAREA 0.5292 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 61.1937 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 326.832 LAYER met4 ;
    ANTENNAGATEAREA 0.441 LAYER met4 ; 
    ANTENNAMAXAREACAR 186.053 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 972.265 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via4 ;
  END dmem_addr[6]
  PIN dmem_addr[5] 
    ANTENNAPARTIALMETALAREA 14.4554 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 71.89 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.441 LAYER met2 ; 
    ANTENNAMAXAREACAR 40.2968 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 192.654 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.376417 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.538 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.336 LAYER met3 ;
    ANTENNAGATEAREA 0.441 LAYER met3 ; 
    ANTENNAMAXAREACAR 41.5167 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 200.219 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.46712 LAYER via3 ;
    ANTENNADIFFAREA 0.5292 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 33.8598 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 181.056 LAYER met4 ;
    ANTENNAGATEAREA 0.441 LAYER met4 ; 
    ANTENNAMAXAREACAR 118.296 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 610.776 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.46712 LAYER via4 ;
  END dmem_addr[5]
  PIN dmem_addr[4] 
    ANTENNAPARTIALMETALAREA 3.9372 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 19.299 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met2 ; 
    ANTENNAMAXAREACAR 30.5835 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 143.194 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 1.159 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.648 LAYER met3 ;
    ANTENNAGATEAREA 0.1575 LAYER met3 ; 
    ANTENNAMAXAREACAR 37.9422 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 185.403 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via3 ;
    ANTENNADIFFAREA 0.5292 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 14.4018 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 77.28 LAYER met4 ;
    ANTENNAGATEAREA 0.441 LAYER met4 ; 
    ANTENNAMAXAREACAR 70.5994 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 360.641 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via4 ;
  END dmem_addr[4]
  PIN dmem_addr[3] 
    ANTENNAPARTIALMETALAREA 3.7762 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 18.494 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met2 ; 
    ANTENNAMAXAREACAR 26.9098 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 125.283 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 1.849 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 10.328 LAYER met3 ;
    ANTENNAGATEAREA 0.1575 LAYER met3 ; 
    ANTENNAMAXAREACAR 38.6495 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 190.857 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via3 ;
    ANTENNADIFFAREA 0.5292 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 16.2648 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 87.216 LAYER met4 ;
    ANTENNAGATEAREA 0.441 LAYER met4 ; 
    ANTENNAMAXAREACAR 75.5312 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 388.626 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via4 ;
  END dmem_addr[3]
  PIN dmem_addr[2] 
    ANTENNAPARTIALMETALAREA 4.6144 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 22.911 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 4.5451 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 24.68 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.08 LAYER via3 ;
    ANTENNADIFFAREA 0.5292 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 48.4992 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 260.544 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.441 LAYER met4 ; 
    ANTENNAMAXAREACAR 137.847 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 731.022 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via4 ;
  END dmem_addr[2]
  PIN dmem_addr[1] 
    ANTENNAPARTIALMETALAREA 7.1966 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 35.714 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.567 LAYER met2 ; 
    ANTENNAMAXAREACAR 13.778 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 65.9189 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.110229 LAYER via2 ;
    ANTENNADIFFAREA 0.5292 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 27.0009 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 145.872 LAYER met3 ;
    ANTENNAGATEAREA 2.142 LAYER met3 ; 
    ANTENNAMAXAREACAR 29.3255 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 144.111 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.440917 LAYER via3 ;
  END dmem_addr[1]
  PIN dmem_addr[0] 
    ANTENNAPARTIALMETALAREA 2.3604 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 11.641 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.5292 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 28.2921 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 152.768 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.8585 LAYER met3 ; 
    ANTENNAMAXAREACAR 77.9863 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 385.86 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via3 ;
  END dmem_addr[0]
  PIN dmem_be[3] 
    ANTENNADIFFAREA 0.5178 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 6.8193 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 33.9885 LAYER met2 ;
  END dmem_be[3]
  PIN dmem_be[2] 
    ANTENNAPARTIALMETALAREA 0.5894 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.786 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.5178 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 0.8088 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.784 LAYER met3 ;
  END dmem_be[2]
  PIN dmem_be[1] 
    ANTENNADIFFAREA 0.5178 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 7.3387 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 36.5855 LAYER met2 ;
  END dmem_be[1]
  PIN dmem_be[0] 
    ANTENNADIFFAREA 0.5178 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 6.8837 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 34.3105 LAYER met2 ;
  END dmem_be[0]
  PIN dmem_wdata[31] 
    ANTENNAPARTIALMETALAREA 1.7808 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 8.743 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.4648 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 13.616 LAYER met3 ;
  END dmem_wdata[31]
  PIN dmem_wdata[30] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 5.9821 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 29.8025 LAYER met2 ;
  END dmem_wdata[30]
  PIN dmem_wdata[29] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 5.4084 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 28.84 LAYER met4 ;
  END dmem_wdata[29]
  PIN dmem_wdata[28] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 13.0674 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 69.688 LAYER met4 ;
  END dmem_wdata[28]
  PIN dmem_wdata[27] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 6.0465 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 30.1245 LAYER met2 ;
  END dmem_wdata[27]
  PIN dmem_wdata[26] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 4.3721 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 21.7525 LAYER met2 ;
  END dmem_wdata[26]
  PIN dmem_wdata[25] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 5.2093 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 25.9385 LAYER met2 ;
  END dmem_wdata[25]
  PIN dmem_wdata[24] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 2.0964 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.176 LAYER met4 ;
  END dmem_wdata[24]
  PIN dmem_wdata[23] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 4.4365 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 22.0745 LAYER met2 ;
  END dmem_wdata[23]
  PIN dmem_wdata[22] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 5.6601 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 28.1925 LAYER met2 ;
  END dmem_wdata[22]
  PIN dmem_wdata[21] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 5.6601 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 28.1925 LAYER met2 ;
  END dmem_wdata[21]
  PIN dmem_wdata[20] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 4.7874 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 25.528 LAYER met4 ;
  END dmem_wdata[20]
  PIN dmem_wdata[19] 
    ANTENNAPARTIALMETALAREA 6.0956 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 30.317 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 0.6018 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.68 LAYER met3 ;
  END dmem_wdata[19]
  PIN dmem_wdata[18] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 5.4669 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 27.2265 LAYER met2 ;
  END dmem_wdata[18]
  PIN dmem_wdata[17] 
    ANTENNAPARTIALMETALAREA 1.974 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 9.709 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 1.3608 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.728 LAYER met3 ;
  END dmem_wdata[17]
  PIN dmem_wdata[16] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 1.0614 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.656 LAYER met4 ;
  END dmem_wdata[16]
  PIN dmem_wdata[15] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 4.7874 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 25.528 LAYER met4 ;
  END dmem_wdata[15]
  PIN dmem_wdata[14] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 7.2714 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 38.776 LAYER met4 ;
  END dmem_wdata[14]
  PIN dmem_wdata[13] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 3.7281 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 18.5325 LAYER met2 ;
  END dmem_wdata[13]
  PIN dmem_wdata[12] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 4.3734 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 23.32 LAYER met4 ;
  END dmem_wdata[12]
  PIN dmem_wdata[11] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 6.4434 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 34.36 LAYER met4 ;
  END dmem_wdata[11]
  PIN dmem_wdata[10] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 5.4084 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 28.84 LAYER met4 ;
  END dmem_wdata[10]
  PIN dmem_wdata[9] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 1.0614 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.656 LAYER met4 ;
  END dmem_wdata[9]
  PIN dmem_wdata[8] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 4.5804 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 24.424 LAYER met4 ;
  END dmem_wdata[8]
  PIN dmem_wdata[7] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 52.5162 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 280.552 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.756 LAYER met4 ; 
    ANTENNAMAXAREACAR 89.0154 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 465.75 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.502646 LAYER via4 ;
  END dmem_wdata[7]
  PIN dmem_wdata[6] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 60.5892 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 323.608 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.756 LAYER met4 ; 
    ANTENNAMAXAREACAR 115.814 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 605.433 LAYER met4 ;
    ANTENNAMAXCUTCAR 1.01058 LAYER via4 ;
  END dmem_wdata[6]
  PIN dmem_wdata[5] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 11.8353 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 63.112 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.756 LAYER met4 ; 
    ANTENNAMAXAREACAR 70.0348 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 353.002 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.52381 LAYER via4 ;
  END dmem_wdata[5]
  PIN dmem_wdata[4] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 9.7653 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 52.072 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.756 LAYER met4 ; 
    ANTENNAMAXAREACAR 59.8754 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 303.445 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.52381 LAYER via4 ;
  END dmem_wdata[4]
  PIN dmem_wdata[3] 
    ANTENNAPARTIALMETALAREA 0.9758 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 4.718 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 5.9506 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 33.144 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met3 ; 
    ANTENNAMAXAREACAR 36.9511 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 186.146 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.777778 LAYER via3 ;
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 7.7778 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 41.952 LAYER met4 ;
    ANTENNAGATEAREA 0.756 LAYER met4 ; 
    ANTENNAMAXAREACAR 47.2392 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 241.638 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.777778 LAYER via4 ;
  END dmem_wdata[3]
  PIN dmem_wdata[2] 
    ANTENNAPARTIALMETALAREA 5.7736 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 28.707 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 12.7962 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 69.648 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.756 LAYER met3 ; 
    ANTENNAMAXAREACAR 50.8046 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 253.825 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END dmem_wdata[2]
  PIN dmem_wdata[1] 
    ANTENNAPARTIALMETALAREA 6.6819 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 32.8615 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met2 ; 
    ANTENNAMAXAREACAR 45.1267 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 216.232 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.08 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 9.2382 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 51.152 LAYER met3 ;
    ANTENNAGATEAREA 0.756 LAYER met3 ; 
    ANTENNAMAXAREACAR 57.3465 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 283.893 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via3 ;
  END dmem_wdata[1]
  PIN dmem_wdata[0] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 10.9191 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 58.696 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.756 LAYER met4 ; 
    ANTENNAMAXAREACAR 38.616 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 195.662 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.904762 LAYER via4 ;
  END dmem_wdata[0]
  PIN dmem_rdata[31] 
    ANTENNAPARTIALMETALAREA 7.5446 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 37.562 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2835 LAYER met2 ; 
    ANTENNAMAXAREACAR 28.1044 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 136.698 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.220459 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 2.8939 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.896 LAYER met3 ;
    ANTENNAGATEAREA 0.567 LAYER met3 ; 
    ANTENNAMAXAREACAR 33.2083 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 164.734 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.291005 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 12.9528 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 69.552 LAYER met4 ;
    ANTENNAGATEAREA 0.8505 LAYER met4 ; 
    ANTENNAMAXAREACAR 48.4379 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 246.511 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.361552 LAYER via4 ;
  END dmem_rdata[31]
  PIN dmem_rdata[30] 
    ANTENNAPARTIALMETALAREA 6.3559 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 31.5105 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2835 LAYER met2 ; 
    ANTENNAMAXAREACAR 24.0434 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 115.508 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.220459 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 6.3096 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 34.592 LAYER met3 ;
    ANTENNAGATEAREA 0.8505 LAYER met3 ; 
    ANTENNAMAXAREACAR 31.4621 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 156.18 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.361552 LAYER via3 ;
  END dmem_rdata[30]
  PIN dmem_rdata[29] 
    ANTENNAPARTIALMETALAREA 5.0008 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 24.843 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 2.1504 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.88 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.8505 LAYER met3 ; 
    ANTENNAMAXAREACAR 10.2532 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 49.1952 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.220459 LAYER via3 ;
  END dmem_rdata[29]
  PIN dmem_rdata[28] 
    ANTENNAPARTIALMETALAREA 0.1127 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4025 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 4.2012 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 24.288 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.8505 LAYER met3 ; 
    ANTENNAMAXAREACAR 31.8942 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 158.399 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.361552 LAYER via3 ;
  END dmem_rdata[28]
  PIN dmem_rdata[27] 
    ANTENNAPARTIALMETALAREA 0.4928 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.303 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.2509 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.808 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 13.3668 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 71.76 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.8505 LAYER met4 ; 
    ANTENNAMAXAREACAR 37.0696 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 187.461 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.26749 LAYER via4 ;
  END dmem_rdata[27]
  PIN dmem_rdata[26] 
    ANTENNAPARTIALMETALAREA 7.1364 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 35.413 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2835 LAYER met2 ; 
    ANTENNAMAXAREACAR 26.7965 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 129.273 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.220459 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 3.919 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 21.368 LAYER met3 ;
    ANTENNAGATEAREA 0.2835 LAYER met3 ; 
    ANTENNAMAXAREACAR 40.6201 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 204.646 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.361552 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 37.1817 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 198.768 LAYER met4 ;
    ANTENNAGATEAREA 0.8505 LAYER met4 ; 
    ANTENNAMAXAREACAR 84.3376 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 438.353 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.361552 LAYER via4 ;
  END dmem_rdata[26]
  PIN dmem_rdata[25] 
    ANTENNAPARTIALMETALAREA 5.7414 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 28.546 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 10.2676 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 55.688 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.567 LAYER met3 ; 
    ANTENNAMAXAREACAR 20.1549 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 104.464 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.291005 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 9.6928 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 48.04 LAYER met4 ;
    ANTENNAGATEAREA 0.567 LAYER met4 ; 
    ANTENNAMAXAREACAR 37.2497 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 189.19 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 0.64 LAYER via4 ;
    ANTENNAMAXCUTCAR 1.41975 LAYER via4 ;
    ANTENNAPARTIALMETALAREA 37.136 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 63.384 LAYER met5 ;
    ANTENNAGATEAREA 0.8505 LAYER met5 ; 
    ANTENNAMAXAREACAR 121.355 LAYER met5 ;
    ANTENNAMAXSIDEAREACAR 472.079 LAYER met5 ;
  END dmem_rdata[25]
  PIN dmem_rdata[24] 
    ANTENNAPARTIALMETALAREA 47.7552 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 255.16 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.8505 LAYER met4 ; 
    ANTENNAMAXAREACAR 75.1691 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 395.467 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.502646 LAYER via4 ;
  END dmem_rdata[24]
  PIN dmem_rdata[23] 
    ANTENNAPARTIALMETALAREA 4.2602 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 21.14 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 3.9636 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 22.08 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.134 LAYER met3 ; 
    ANTENNAMAXAREACAR 15.8705 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 76.1852 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.220459 LAYER via3 ;
  END dmem_rdata[23]
  PIN dmem_rdata[22] 
    ANTENNAPARTIALMETALAREA 17.4144 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 92.872 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.8505 LAYER met4 ; 
    ANTENNAMAXAREACAR 41.5188 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 213.922 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.408583 LAYER via4 ;
  END dmem_rdata[22]
  PIN dmem_rdata[21] 
    ANTENNAPARTIALMETALAREA 3.262 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 16.149 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.26895 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.832 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 13.9878 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 75.072 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.8505 LAYER met4 ; 
    ANTENNAMAXAREACAR 36.6566 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 187.407 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.276308 LAYER via4 ;
  END dmem_rdata[21]
  PIN dmem_rdata[20] 
    ANTENNAPARTIALMETALAREA 3.9382 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 19.53 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.4 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.6 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 40.3956 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 216.384 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.8505 LAYER met4 ; 
    ANTENNAMAXAREACAR 60.978 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 322.444 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.643739 LAYER via4 ;
  END dmem_rdata[20]
  PIN dmem_rdata[19] 
    ANTENNAPARTIALMETALAREA 19.4844 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 103.912 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.8505 LAYER met4 ; 
    ANTENNAMAXAREACAR 68.631 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 350.626 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.346855 LAYER via4 ;
  END dmem_rdata[19]
  PIN dmem_rdata[18] 
    ANTENNAPARTIALMETALAREA 37.6122 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 201.064 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.134 LAYER met4 ; 
    ANTENNAMAXAREACAR 63.6095 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 328.131 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.432099 LAYER via4 ;
  END dmem_rdata[18]
  PIN dmem_rdata[17] 
    ANTENNAPARTIALMETALAREA 10.3638 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 51.422 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2835 LAYER met2 ; 
    ANTENNAMAXAREACAR 40.8478 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 197.813 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.299824 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 1.642 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.224 LAYER met3 ;
    ANTENNAGATEAREA 0.2835 LAYER met3 ; 
    ANTENNAMAXAREACAR 46.6397 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 230.349 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.440917 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 27.2358 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 145.728 LAYER met4 ;
    ANTENNAGATEAREA 0.8505 LAYER met4 ; 
    ANTENNAMAXAREACAR 78.663 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 401.693 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.440917 LAYER via4 ;
  END dmem_rdata[17]
  PIN dmem_rdata[16] 
    ANTENNAPARTIALMETALAREA 22.7964 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 121.576 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.8505 LAYER met4 ; 
    ANTENNAMAXAREACAR 39.676 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 205.178 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.26749 LAYER via4 ;
  END dmem_rdata[16]
  PIN dmem_rdata[15] 
    ANTENNAPARTIALMETALAREA 1.8452 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 9.065 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 1.021 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.912 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 6.7428 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 36.432 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.8505 LAYER met4 ; 
    ANTENNAMAXAREACAR 17.8104 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 87.8901 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.173427 LAYER via4 ;
  END dmem_rdata[15]
  PIN dmem_rdata[14] 
    ANTENNAPARTIALMETALAREA 6.3854 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 31.766 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 5.2347 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 28.384 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.567 LAYER met3 ; 
    ANTENNAMAXAREACAR 13.2573 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 66.3263 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.220459 LAYER via3 ;
  END dmem_rdata[14]
  PIN dmem_rdata[13] 
    ANTENNAPARTIALMETALAREA 8.4677 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 42.1225 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.567 LAYER met2 ; 
    ANTENNAMAXAREACAR 17.4302 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 83.2601 LAYER met2 ;
    ANTENNAMAXCUTCAR 0.0793651 LAYER via2 ;
  END dmem_rdata[13]
  PIN dmem_rdata[12] 
    ANTENNAPARTIALMETALAREA 14.3094 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 76.312 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.567 LAYER met4 ; 
    ANTENNAMAXAREACAR 32.4499 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 168.318 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.220459 LAYER via4 ;
  END dmem_rdata[12]
  PIN dmem_rdata[11] 
    ANTENNAPARTIALMETALAREA 9.9624 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 53.128 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.567 LAYER met4 ; 
    ANTENNAMAXAREACAR 27.7363 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 141.627 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.220459 LAYER via4 ;
  END dmem_rdata[11]
  PIN dmem_rdata[10] 
    ANTENNAPARTIALMETALAREA 6.2781 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 31.1745 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.567 LAYER met2 ; 
    ANTENNAMAXAREACAR 14.0376 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 66.2972 LAYER met2 ;
    ANTENNAMAXCUTCAR 0.0793651 LAYER via2 ;
  END dmem_rdata[10]
  PIN dmem_rdata[9] 
    ANTENNAPARTIALMETALAREA 1.0614 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.656 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.567 LAYER met4 ; 
    ANTENNAMAXAREACAR 16.7727 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 81.2178 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.299824 LAYER via4 ;
  END dmem_rdata[9]
  PIN dmem_rdata[8] 
    ANTENNAPARTIALMETALAREA 10.5834 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 56.44 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.567 LAYER met4 ; 
    ANTENNAMAXAREACAR 24.7944 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 127.201 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.220459 LAYER via4 ;
  END dmem_rdata[8]
  PIN dmem_rdata[7] 
    ANTENNAPARTIALMETALAREA 5.9024 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 29.351 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 1.6368 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.2 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.567 LAYER met3 ; 
    ANTENNAMAXAREACAR 18.5422 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 89.366 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.149912 LAYER via3 ;
  END dmem_rdata[7]
  PIN dmem_rdata[6] 
    ANTENNAPARTIALMETALAREA 6.8574 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 36.568 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2835 LAYER met4 ; 
    ANTENNAMAXAREACAR 33.1372 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 171.868 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.361552 LAYER via4 ;
  END dmem_rdata[6]
  PIN dmem_rdata[5] 
    ANTENNAPARTIALMETALAREA 2.5214 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 12.446 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.6708 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.048 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2835 LAYER met3 ; 
    ANTENNAMAXAREACAR 13.3439 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 64.7813 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.220459 LAYER via3 ;
  END dmem_rdata[5]
  PIN dmem_rdata[4] 
    ANTENNAPARTIALMETALAREA 5.0161 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 24.9725 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2835 LAYER met2 ; 
    ANTENNAMAXAREACAR 19.3235 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 92.4533 LAYER met2 ;
    ANTENNAMAXCUTCAR 0.0793651 LAYER via2 ;
  END dmem_rdata[4]
  PIN dmem_rdata[3] 
    ANTENNAPARTIALMETALAREA 5.1491 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 25.6375 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2835 LAYER met2 ; 
    ANTENNAMAXAREACAR 19.7926 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 94.7989 LAYER met2 ;
    ANTENNAMAXCUTCAR 0.0793651 LAYER via2 ;
  END dmem_rdata[3]
  PIN dmem_rdata[2] 
    ANTENNAPARTIALMETALAREA 4.9517 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 24.6505 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2835 LAYER met2 ; 
    ANTENNAMAXAREACAR 19.0903 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 91.3104 LAYER met2 ;
    ANTENNAMAXCUTCAR 0.0793651 LAYER via2 ;
  END dmem_rdata[2]
  PIN dmem_rdata[1] 
    ANTENNAPARTIALMETALAREA 3.2298 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 15.988 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.4638 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.944 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2835 LAYER met3 ; 
    ANTENNAMAXAREACAR 12.3 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 58.4568 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.220459 LAYER via3 ;
  END dmem_rdata[1]
  PIN dmem_rdata[0] 
    ANTENNAPARTIALMETALAREA 5.6601 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 28.1925 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2835 LAYER met2 ; 
    ANTENNAMAXAREACAR 22.7578 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 108.764 LAYER met2 ;
    ANTENNAMAXCUTCAR 0.0793651 LAYER via2 ;
  END dmem_rdata[0]
  PIN rvfi_valid 
    ANTENNAPARTIALMETALAREA 2.135 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 10.514 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 1.0584 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 69.8257 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 380.8 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 19.971 LAYER met3 ; 
    ANTENNAMAXAREACAR 14.6875 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 67.8494 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.454384 LAYER via3 ;
    ANTENNADIFFAREA 1.0584 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 0.5328 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.312 LAYER met4 ;
    ANTENNAGATEAREA 20.286 LAYER met4 ; 
    ANTENNAMAXAREACAR 14.7137 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 68.0127 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.454384 LAYER via4 ;
  END rvfi_valid
  PIN rvfi_pc[31] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 23.0034 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 122.68 LAYER met4 ;
  END rvfi_pc[31]
  PIN rvfi_pc[30] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 28.1784 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 150.28 LAYER met4 ;
  END rvfi_pc[30]
  PIN rvfi_pc[29] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 14.3094 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 76.312 LAYER met4 ;
  END rvfi_pc[29]
  PIN rvfi_pc[28] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 21.5544 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 114.952 LAYER met4 ;
  END rvfi_pc[28]
  PIN rvfi_pc[27] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 17.6214 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 93.976 LAYER met4 ;
  END rvfi_pc[27]
  PIN rvfi_pc[26] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 11.2044 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 59.752 LAYER met4 ;
  END rvfi_pc[26]
  PIN rvfi_pc[25] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 39.9774 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 213.208 LAYER met4 ;
  END rvfi_pc[25]
  PIN rvfi_pc[24] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 23.8314 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 127.096 LAYER met4 ;
  END rvfi_pc[24]
  PIN rvfi_pc[23] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 29.9532 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 160.216 LAYER met4 ;
  END rvfi_pc[23]
  PIN rvfi_pc[22] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 39.4752 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 211 LAYER met4 ;
  END rvfi_pc[22]
  PIN rvfi_pc[21] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 41.5452 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 222.04 LAYER met4 ;
  END rvfi_pc[21]
  PIN rvfi_pc[20] 
    ANTENNAPARTIALMETALAREA 3.4937 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 17.3075 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 0.5328 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.312 LAYER met3 ;
  END rvfi_pc[20]
  PIN rvfi_pc[19] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 40.0962 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 214.312 LAYER met4 ;
  END rvfi_pc[19]
  PIN rvfi_pc[18] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 40.3914 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 215.416 LAYER met4 ;
  END rvfi_pc[18]
  PIN rvfi_pc[17] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 43.4964 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 231.976 LAYER met4 ;
  END rvfi_pc[17]
  PIN rvfi_pc[16] 
    ANTENNAPARTIALMETALAREA 6.8404 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 32.352 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 0.64 LAYER via4 ;
    ANTENNADIFFAREA 0.50085 LAYER met5 ; 
    ANTENNAPARTIALMETALAREA 34.576 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 55.704 LAYER met5 ;
  END rvfi_pc[16]
  PIN rvfi_pc[15] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 6.6504 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 35.464 LAYER met4 ;
  END rvfi_pc[15]
  PIN rvfi_pc[14] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 3.7281 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 18.5325 LAYER met2 ;
  END rvfi_pc[14]
  PIN rvfi_pc[13] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 67.5084 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 360.04 LAYER met4 ;
  END rvfi_pc[13]
  PIN rvfi_pc[12] 
    ANTENNAPARTIALMETALAREA 0.5894 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.786 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 2.539 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 14.008 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 75.2926 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 398.376 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 0.64 LAYER via4 ;
    ANTENNADIFFAREA 0.50085 LAYER met5 ; 
    ANTENNAPARTIALMETALAREA 142.768 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 217.992 LAYER met5 ;
  END rvfi_pc[12]
  PIN rvfi_pc[11] 
    ANTENNAPARTIALMETALAREA 6.9069 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 34.3735 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 3.16 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 17.32 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 63.8748 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 341.136 LAYER met4 ;
  END rvfi_pc[11]
  PIN rvfi_pc[10] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 79.8402 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 426.28 LAYER met4 ;
  END rvfi_pc[10]
  PIN rvfi_pc[9] 
    ANTENNAPARTIALMETALAREA 0.9758 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 4.718 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 5.851 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 31.672 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 76.7088 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 409.584 LAYER met4 ;
  END rvfi_pc[9]
  PIN rvfi_pc[8] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 68.4552 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 365.56 LAYER met4 ;
  END rvfi_pc[8]
  PIN rvfi_pc[7] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 66.0594 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 352.312 LAYER met4 ;
  END rvfi_pc[7]
  PIN rvfi_pc[6] 
    ANTENNAPARTIALMETALAREA 10.0562 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 50.12 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.607 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.704 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 48.1428 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 257.232 LAYER met4 ;
  END rvfi_pc[6]
  PIN rvfi_pc[5] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 62.5404 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 333.544 LAYER met4 ;
  END rvfi_pc[5]
  PIN rvfi_pc[4] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 4.3721 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 21.7525 LAYER met2 ;
  END rvfi_pc[4]
  PIN rvfi_pc[3] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 50.5212 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 269.912 LAYER met4 ;
  END rvfi_pc[3]
  PIN rvfi_pc[2] 
    ANTENNAPARTIALMETALAREA 1.8034 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.488 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 0.64 LAYER via4 ;
    ANTENNADIFFAREA 0.50085 LAYER met5 ; 
    ANTENNAPARTIALMETALAREA 6.976 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 14.304 LAYER met5 ;
  END rvfi_pc[2]
  PIN rvfi_pc[1] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 3.4705 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 17.2445 LAYER met2 ;
  END rvfi_pc[1]
  PIN rvfi_pc[0] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 2.0537 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 10.1605 LAYER met2 ;
  END rvfi_pc[0]
  PIN rvfi_insn[31] 
    ANTENNAPARTIALMETALAREA 2.4248 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 11.963 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 3.091 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 16.952 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 17.7138 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 94.944 LAYER met4 ;
  END rvfi_insn[31]
  PIN rvfi_insn[30] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 11.7065 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 58.3065 LAYER met2 ;
  END rvfi_insn[30]
  PIN rvfi_insn[29] 
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 6.1674 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 32.888 LAYER met3 ;
  END rvfi_insn[29]
  PIN rvfi_insn[28] 
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 7.9614 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 42.456 LAYER met3 ;
  END rvfi_insn[28]
  PIN rvfi_insn[27] 
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 4.9254 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 26.264 LAYER met3 ;
  END rvfi_insn[27]
  PIN rvfi_insn[26] 
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 4.9944 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 26.632 LAYER met3 ;
  END rvfi_insn[26]
  PIN rvfi_insn[25] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 10.3541 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 51.5445 LAYER met2 ;
  END rvfi_insn[25]
  PIN rvfi_insn[24] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 3.7925 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 18.8545 LAYER met2 ;
  END rvfi_insn[24]
  PIN rvfi_insn[23] 
    ANTENNAPARTIALMETALAREA 4.55 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 22.589 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 4.5348 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 24.656 LAYER met3 ;
  END rvfi_insn[23]
  PIN rvfi_insn[22] 
    ANTENNAPARTIALMETALAREA 1.8452 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 9.065 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 1.6368 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.2 LAYER met3 ;
  END rvfi_insn[22]
  PIN rvfi_insn[21] 
    ANTENNAPARTIALMETALAREA 1.9985 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 9.8315 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 0.8088 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.784 LAYER met3 ;
  END rvfi_insn[21]
  PIN rvfi_insn[20] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 7.5277 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 37.5305 LAYER met2 ;
  END rvfi_insn[20]
  PIN rvfi_insn[19] 
    ANTENNAPARTIALMETALAREA 4.2021 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 20.8495 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 1.4988 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.464 LAYER met3 ;
  END rvfi_insn[19]
  PIN rvfi_insn[18] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 2.5045 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 12.4145 LAYER met2 ;
  END rvfi_insn[18]
  PIN rvfi_insn[17] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 2.1109 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 10.3285 LAYER met2 ;
  END rvfi_insn[17]
  PIN rvfi_insn[16] 
    ANTENNAPARTIALMETALAREA 8.2458 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 40.95 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 1.4988 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.464 LAYER met3 ;
  END rvfi_insn[16]
  PIN rvfi_insn[15] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 5.0847 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 25.3155 LAYER met2 ;
  END rvfi_insn[15]
  PIN rvfi_insn[14] 
    ANTENNAPARTIALMETALAREA 9.5473 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 47.5755 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 9.0888 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 48.944 LAYER met3 ;
  END rvfi_insn[14]
  PIN rvfi_insn[13] 
    ANTENNAPARTIALMETALAREA 2.3282 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 11.48 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 1.987 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 11.064 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 10.2618 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 55.2 LAYER met4 ;
  END rvfi_insn[13]
  PIN rvfi_insn[12] 
    ANTENNAPARTIALMETALAREA 5.6448 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 28.063 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 4.1208 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 22.448 LAYER met3 ;
  END rvfi_insn[12]
  PIN rvfi_insn[11] 
    ANTENNAPARTIALMETALAREA 2.4892 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 12.285 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 1.4988 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.464 LAYER met3 ;
  END rvfi_insn[11]
  PIN rvfi_insn[10] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 1.9249 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 9.5165 LAYER met2 ;
  END rvfi_insn[10]
  PIN rvfi_insn[9] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 2.1109 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 10.3285 LAYER met2 ;
  END rvfi_insn[9]
  PIN rvfi_insn[8] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 2.5689 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 12.7365 LAYER met2 ;
  END rvfi_insn[8]
  PIN rvfi_insn[7] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 1.4754 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 7.864 LAYER met4 ;
  END rvfi_insn[7]
  PIN rvfi_insn[6] 
    ANTENNAPARTIALMETALAREA 2.2701 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 11.1895 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.4 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.6 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 10.2618 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 55.2 LAYER met4 ;
  END rvfi_insn[6]
  PIN rvfi_insn[5] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 7.1341 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 35.4445 LAYER met2 ;
  END rvfi_insn[5]
  PIN rvfi_insn[4] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 5.4669 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 27.2265 LAYER met2 ;
  END rvfi_insn[4]
  PIN rvfi_insn[3] 
    ANTENNAPARTIALMETALAREA 0.4928 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.303 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 4.6728 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 25.392 LAYER met3 ;
  END rvfi_insn[3]
  PIN rvfi_insn[2] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 2.1181 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 10.4825 LAYER met2 ;
  END rvfi_insn[2]
  PIN rvfi_insn[1] 
    ANTENNAPARTIALMETALAREA 1.7808 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 8.743 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 1.2228 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.992 LAYER met3 ;
  END rvfi_insn[1]
  PIN rvfi_insn[0] 
    ANTENNAPARTIALMETALAREA 2.4248 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 11.963 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 0.5328 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.312 LAYER met3 ;
  END rvfi_insn[0]
  PIN rvfi_rd_we 
    ANTENNADIFFAREA 0.5292 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 28.7112 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 153.592 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.94575 LAYER met4 ; 
    ANTENNAMAXAREACAR 67.3138 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 346.512 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.693088 LAYER via4 ;
  END rvfi_rd_we
  PIN rvfi_rd[4] 
    ANTENNADIFFAREA 0.5292 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 13.4814 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 71.896 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.4885 LAYER met4 ; 
    ANTENNAMAXAREACAR 17.8332 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 82.134 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.412899 LAYER via4 ;
  END rvfi_rd[4]
  PIN rvfi_rd[3] 
    ANTENNAPARTIALMETALAREA 22.9191 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 113.95 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.134 LAYER met2 ; 
    ANTENNAMAXAREACAR 22.6086 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 108.47 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.08 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.149912 LAYER via2 ;
    ANTENNADIFFAREA 0.5292 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 14.9949 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 81.84 LAYER met3 ;
    ANTENNAGATEAREA 2.9925 LAYER met3 ; 
    ANTENNAMAXAREACAR 27.6194 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 135.819 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END rvfi_rd[3]
  PIN rvfi_rd[2] 
    ANTENNAPARTIALMETALAREA 40.1878 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 210.2 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.89 LAYER met4 ; 
    ANTENNAMAXAREACAR 31.5863 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 160.18 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 0.64 LAYER via4 ;
    ANTENNAMAXCUTCAR 0.593348 LAYER via4 ;
    ANTENNADIFFAREA 0.5292 LAYER met5 ; 
    ANTENNAPARTIALMETALAREA 107.072 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 164.448 LAYER met5 ;
    ANTENNAGATEAREA 1.89 LAYER met5 ; 
    ANTENNAMAXAREACAR 88.2381 LAYER met5 ;
    ANTENNAMAXSIDEAREACAR 247.19 LAYER met5 ;
  END rvfi_rd[2]
  PIN rvfi_rd[1] 
    ANTENNADIFFAREA 0.5292 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 28.7994 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 153.592 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.41825 LAYER met4 ; 
    ANTENNAMAXAREACAR 28.6406 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 145.18 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.226616 LAYER via4 ;
  END rvfi_rd[1]
  PIN rvfi_rd[0] 
    ANTENNAPARTIALMETALAREA 0.3962 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.82 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 11.371 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 61.112 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 0.5292 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 29.8386 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 160.08 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.66225 LAYER met4 ; 
    ANTENNAMAXAREACAR 76.1934 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 394.065 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.523677 LAYER via4 ;
  END rvfi_rd[0]
  PIN rvfi_rd_wdata[31] 
    ANTENNAPARTIALMETALAREA 10.7066 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 52.759 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met2 ; 
    ANTENNAMAXAREACAR 25.6906 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 119.634 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.08 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.312169 LAYER via2 ;
    ANTENNADIFFAREA 0.5292 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 50.5155 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 275.968 LAYER met3 ;
    ANTENNAGATEAREA 5.4495 LAYER met3 ; 
    ANTENNAMAXAREACAR 41.3758 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 201.882 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via3 ;
  END rvfi_rd_wdata[31]
  PIN rvfi_rd_wdata[30] 
    ANTENNAPARTIALMETALAREA 7.2339 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 35.5565 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.63 LAYER met2 ; 
    ANTENNAMAXAREACAR 16.6398 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 75.7437 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.206349 LAYER via2 ;
    ANTENNADIFFAREA 0.5292 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 36.615 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 199.936 LAYER met3 ;
    ANTENNAGATEAREA 5.4495 LAYER met3 ; 
    ANTENNAMAXAREACAR 31.3056 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 151.571 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via3 ;
  END rvfi_rd_wdata[30]
  PIN rvfi_rd_wdata[29] 
    ANTENNAPARTIALMETALAREA 0.2996 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.337 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 9.8251 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 54.264 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.26 LAYER met3 ; 
    ANTENNAMAXAREACAR 23.1367 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 111.883 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.68254 LAYER via3 ;
    ANTENNADIFFAREA 0.5292 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 12.4506 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 67.344 LAYER met4 ;
    ANTENNAGATEAREA 5.4495 LAYER met4 ; 
    ANTENNAMAXAREACAR 46.9263 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 230.996 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.708514 LAYER via4 ;
  END rvfi_rd_wdata[29]
  PIN rvfi_rd_wdata[28] 
    ANTENNADIFFAREA 1.0584 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 17.0426 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 84.826 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 1.0584 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 12.2194 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 66.088 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.945 LAYER met3 ; 
    ANTENNAMAXAREACAR 24.1122 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 117.265 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.439153 LAYER via3 ;
    ANTENNADIFFAREA 1.0584 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 4.8798 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 26.496 LAYER met4 ;
    ANTENNAGATEAREA 5.4495 LAYER met4 ; 
    ANTENNAMAXAREACAR 45.5575 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 224.608 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.659674 LAYER via4 ;
  END rvfi_rd_wdata[28]
  PIN rvfi_rd_wdata[27] 
    ANTENNAPARTIALMETALAREA 9.5634 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 46.515 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.9135 LAYER met2 ; 
    ANTENNAMAXAREACAR 13.5001 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 58.8941 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.16 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.318008 LAYER via2 ;
    ANTENNADIFFAREA 0.5292 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 52.9206 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 288.8 LAYER met3 ;
    ANTENNAGATEAREA 5.4495 LAYER met3 ; 
    ANTENNAMAXAREACAR 57.1568 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 280.967 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via3 ;
  END rvfi_rd_wdata[27]
  PIN rvfi_rd_wdata[26] 
    ANTENNAPARTIALMETALAREA 70.8223 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 383.312 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 5.4495 LAYER met3 ; 
    ANTENNAMAXAREACAR 34.1193 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 168.177 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.658134 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 9.8308 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 48.776 LAYER met4 ;
    ANTENNAGATEAREA 5.4495 LAYER met4 ; 
    ANTENNAMAXAREACAR 35.9233 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 177.128 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 0.64 LAYER via4 ;
    ANTENNAMAXCUTCAR 0.775576 LAYER via4 ;
    ANTENNADIFFAREA 1.0584 LAYER met5 ; 
    ANTENNAPARTIALMETALAREA 363.568 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 549.192 LAYER met5 ;
    ANTENNAGATEAREA 5.4495 LAYER met5 ; 
    ANTENNAMAXAREACAR 102.639 LAYER met5 ;
    ANTENNAMAXSIDEAREACAR 277.906 LAYER met5 ;
  END rvfi_rd_wdata[26]
  PIN rvfi_rd_wdata[25] 
    ANTENNAPARTIALMETALAREA 50.3584 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 273.696 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 5.4495 LAYER met3 ; 
    ANTENNAMAXAREACAR 25.9787 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 124.84 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.912102 LAYER via3 ;
    ANTENNADIFFAREA 0.5292 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 10.8828 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 58.512 LAYER met4 ;
    ANTENNAGATEAREA 5.4495 LAYER met4 ; 
    ANTENNAMAXAREACAR 27.9757 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 135.577 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.912102 LAYER via4 ;
  END rvfi_rd_wdata[25]
  PIN rvfi_rd_wdata[24] 
    ANTENNAPARTIALMETALAREA 2.2316 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 10.997 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.676 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.072 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 69.8914 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 370.04 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 5.4495 LAYER met4 ; 
    ANTENNAMAXAREACAR 63.1629 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 314.926 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 0.64 LAYER via4 ;
    ANTENNAMAXCUTCAR 1.29601 LAYER via4 ;
    ANTENNADIFFAREA 1.0584 LAYER met5 ; 
    ANTENNAPARTIALMETALAREA 68.8 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 107.04 LAYER met5 ;
    ANTENNAGATEAREA 5.4495 LAYER met5 ; 
    ANTENNAMAXAREACAR 75.7879 LAYER met5 ;
    ANTENNAMAXSIDEAREACAR 334.569 LAYER met5 ;
  END rvfi_rd_wdata[24]
  PIN rvfi_rd_wdata[23] 
    ANTENNAPARTIALMETALAREA 7.77 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 38.689 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 1.0584 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 13.6504 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 73.264 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 1.0584 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 45.1971 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 242.928 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 6.0165 LAYER met4 ; 
    ANTENNAMAXAREACAR 55.3058 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 289.539 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.928062 LAYER via4 ;
  END rvfi_rd_wdata[23]
  PIN rvfi_rd_wdata[22] 
    ANTENNAPARTIALMETALAREA 3.0034 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 14.63 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met2 ; 
    ANTENNAMAXAREACAR 22.1003 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 100.863 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 8.7403 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 48.008 LAYER met3 ;
    ANTENNAGATEAREA 1.1025 LAYER met3 ; 
    ANTENNAMAXAREACAR 30.028 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 144.408 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.560091 LAYER via3 ;
    ANTENNADIFFAREA 0.5292 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 10.9233 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 59.664 LAYER met4 ;
    ANTENNAGATEAREA 5.4495 LAYER met4 ; 
    ANTENNAMAXAREACAR 40.0114 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 196.458 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.728539 LAYER via4 ;
  END rvfi_rd_wdata[22]
  PIN rvfi_rd_wdata[21] 
    ANTENNAPARTIALMETALAREA 9.7283 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 47.7925 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.7875 LAYER met2 ; 
    ANTENNAMAXAREACAR 15.3845 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 68.6635 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.193651 LAYER via2 ;
    ANTENNADIFFAREA 0.5292 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 36.1895 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 198.56 LAYER met3 ;
    ANTENNAGATEAREA 3.8745 LAYER met3 ; 
    ANTENNAMAXAREACAR 34.682 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 166.623 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.08 LAYER via3 ;
    ANTENNAMAXCUTCAR 1.17938 LAYER via3 ;
    ANTENNADIFFAREA 0.5292 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 6.8616 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 37.536 LAYER met4 ;
    ANTENNAGATEAREA 5.4495 LAYER met4 ; 
    ANTENNAMAXAREACAR 35.9412 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 173.51 LAYER met4 ;
    ANTENNAMAXCUTCAR 1.17938 LAYER via4 ;
  END rvfi_rd_wdata[21]
  PIN rvfi_rd_wdata[20] 
    ANTENNAPARTIALMETALAREA 2.3604 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 11.641 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 2.884 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.848 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 0.5292 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 65.1168 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 347.76 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 4.347 LAYER met4 ; 
    ANTENNAMAXAREACAR 40.8152 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 205.271 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.659995 LAYER via4 ;
  END rvfi_rd_wdata[20]
  PIN rvfi_rd_wdata[19] 
    ANTENNAPARTIALMETALAREA 1.7808 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 8.743 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.5292 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 32.334 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 176.16 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.5595 LAYER met3 ; 
    ANTENNAMAXAREACAR 37.9994 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 186.112 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.535047 LAYER via3 ;
    ANTENNADIFFAREA 0.5292 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 0.5328 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.312 LAYER met4 ;
    ANTENNAGATEAREA 5.4495 LAYER met4 ; 
    ANTENNAMAXAREACAR 38.0972 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 186.72 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.671958 LAYER via4 ;
  END rvfi_rd_wdata[19]
  PIN rvfi_rd_wdata[18] 
    ANTENNAPARTIALMETALAREA 7.0038 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 34.202 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met2 ; 
    ANTENNAMAXAREACAR 25.2654 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 116.552 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.12 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.52381 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 29.2585 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 159.304 LAYER met3 ;
    ANTENNAGATEAREA 2.8035 LAYER met3 ; 
    ANTENNAMAXAREACAR 35.7018 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 173.376 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.665062 LAYER via3 ;
    ANTENNADIFFAREA 0.5292 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 5.4126 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 29.808 LAYER met4 ;
    ANTENNAGATEAREA 5.4495 LAYER met4 ; 
    ANTENNAMAXAREACAR 38.8303 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 190.455 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.693839 LAYER via4 ;
  END rvfi_rd_wdata[18]
  PIN rvfi_rd_wdata[17] 
    ANTENNAPARTIALMETALAREA 6.2416 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 33.28 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 2.8618 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.608 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 0.64 LAYER via4 ;
    ANTENNADIFFAREA 0.5292 LAYER met5 ; 
    ANTENNAPARTIALMETALAREA 228.144 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 346.056 LAYER met5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 4.662 LAYER met5 ; 
    ANTENNAMAXAREACAR 77.57 LAYER met5 ;
    ANTENNAMAXSIDEAREACAR 214.721 LAYER met5 ;
  END rvfi_rd_wdata[17]
  PIN rvfi_rd_wdata[16] 
    ANTENNAPARTIALMETALAREA 6.2416 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 33.28 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 8.6578 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 42.52 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 0.64 LAYER via4 ;
    ANTENNADIFFAREA 1.0584 LAYER met5 ; 
    ANTENNAPARTIALMETALAREA 319.024 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 486.216 LAYER met5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 5.4495 LAYER met5 ; 
    ANTENNAMAXAREACAR 100.32 LAYER met5 ;
    ANTENNAMAXSIDEAREACAR 291.156 LAYER met5 ;
  END rvfi_rd_wdata[16]
  PIN rvfi_rd_wdata[15] 
    ANTENNAPARTIALMETALAREA 1.974 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 9.709 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.5292 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 9.2958 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 50.048 LAYER met3 ;
  END rvfi_rd_wdata[15]
  PIN rvfi_rd_wdata[14] 
    ANTENNAPARTIALMETALAREA 16.0018 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 86.736 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.26 LAYER met3 ; 
    ANTENNAMAXAREACAR 22.7181 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 110.452 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.68254 LAYER via3 ;
    ANTENNADIFFAREA 0.5292 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 5.0967 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 27.648 LAYER met4 ;
    ANTENNAGATEAREA 5.4495 LAYER met4 ; 
    ANTENNAMAXAREACAR 32.9576 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 162.779 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.68254 LAYER via4 ;
  END rvfi_rd_wdata[14]
  PIN rvfi_rd_wdata[13] 
    ANTENNAPARTIALMETALAREA 6.0312 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 29.995 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.5292 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 8.1228 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 43.792 LAYER met3 ;
  END rvfi_rd_wdata[13]
  PIN rvfi_rd_wdata[12] 
    ANTENNAPARTIALMETALAREA 55.5022 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 301.104 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.6775 LAYER met3 ; 
    ANTENNAMAXAREACAR 69.3424 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 347.473 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.16 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.964519 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 17.896 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 93.672 LAYER met4 ;
    ANTENNAGATEAREA 5.4495 LAYER met4 ; 
    ANTENNAMAXAREACAR 109.93 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 553.12 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 0.64 LAYER via4 ;
    ANTENNAMAXCUTCAR 1.08196 LAYER via4 ;
    ANTENNADIFFAREA 1.0584 LAYER met5 ; 
    ANTENNAPARTIALMETALAREA 271.552 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 415.008 LAYER met5 ;
    ANTENNAGATEAREA 5.4495 LAYER met5 ; 
    ANTENNAMAXAREACAR 159.761 LAYER met5 ;
    ANTENNAMAXSIDEAREACAR 629.275 LAYER met5 ;
  END rvfi_rd_wdata[12]
  PIN rvfi_rd_wdata[11] 
    ANTENNAPARTIALMETALAREA 6.4486 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 34.384 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 6.1048 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 28.904 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 0.64 LAYER via4 ;
    ANTENNADIFFAREA 1.0584 LAYER met5 ; 
    ANTENNAPARTIALMETALAREA 343.696 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 519.384 LAYER met5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 5.4495 LAYER met5 ; 
    ANTENNAMAXAREACAR 121.362 LAYER met5 ;
    ANTENNAMAXSIDEAREACAR 383.704 LAYER met5 ;
  END rvfi_rd_wdata[11]
  PIN rvfi_rd_wdata[10] 
    ANTENNAPARTIALMETALAREA 13.0726 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 69.712 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 44.2618 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 232.408 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 0.64 LAYER via4 ;
    ANTENNADIFFAREA 1.0584 LAYER met5 ; 
    ANTENNAPARTIALMETALAREA 319.04 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 482.4 LAYER met5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 5.4495 LAYER met5 ; 
    ANTENNAMAXAREACAR 107.311 LAYER met5 ;
    ANTENNAMAXSIDEAREACAR 328.079 LAYER met5 ;
  END rvfi_rd_wdata[10]
  PIN rvfi_rd_wdata[9] 
    ANTENNAPARTIALMETALAREA 3.5506 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 18.928 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 38.1133 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 197.768 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 0.64 LAYER via4 ;
    ANTENNADIFFAREA 0.5292 LAYER met5 ; 
    ANTENNAPARTIALMETALAREA 43.408 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 68.952 LAYER met5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 4.032 LAYER met5 ; 
    ANTENNAMAXAREACAR 41.2168 LAYER met5 ;
    ANTENNAMAXSIDEAREACAR 163.977 LAYER met5 ;
  END rvfi_rd_wdata[9]
  PIN rvfi_rd_wdata[8] 
    ANTENNAPARTIALMETALAREA 1.2736 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.784 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 9.1906 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 45.832 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 0.64 LAYER via4 ;
    ANTENNADIFFAREA 1.0584 LAYER met5 ; 
    ANTENNAPARTIALMETALAREA 139.456 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 213.024 LAYER met5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 5.4495 LAYER met5 ; 
    ANTENNAMAXAREACAR 69.7505 LAYER met5 ;
    ANTENNAMAXSIDEAREACAR 256.104 LAYER met5 ;
  END rvfi_rd_wdata[8]
  PIN rvfi_rd_wdata[7] 
    ANTENNAPARTIALMETALAREA 0.1127 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4025 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 4.816 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 26.152 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 0.5292 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 5.7078 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 30.912 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 5.4495 LAYER met4 ; 
    ANTENNAMAXAREACAR 40.7471 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 187.763 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.658134 LAYER via4 ;
  END rvfi_rd_wdata[7]
  PIN rvfi_rd_wdata[6] 
    ANTENNAPARTIALMETALAREA 23.2582 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 126.848 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.4175 LAYER met3 ; 
    ANTENNAMAXAREACAR 56.7368 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 282.059 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.932981 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 19.1467 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 99.872 LAYER met4 ;
    ANTENNAGATEAREA 5.4495 LAYER met4 ; 
    ANTENNAMAXAREACAR 62.9873 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 312.777 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 0.64 LAYER via4 ;
    ANTENNAMAXCUTCAR 1.09582 LAYER via4 ;
    ANTENNADIFFAREA 1.0584 LAYER met5 ; 
    ANTENNAPARTIALMETALAREA 441.568 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 670.032 LAYER met5 ;
    ANTENNAGATEAREA 5.4495 LAYER met5 ; 
    ANTENNAMAXAREACAR 144.016 LAYER met5 ;
    ANTENNAMAXSIDEAREACAR 435.73 LAYER met5 ;
  END rvfi_rd_wdata[6]
  PIN rvfi_rd_wdata[5] 
    ANTENNADIFFAREA 0.5292 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 53.9266 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 292.736 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 5.292 LAYER met3 ; 
    ANTENNAMAXAREACAR 27.5585 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 120.244 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.658352 LAYER via3 ;
    ANTENNADIFFAREA 0.5292 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 3.0168 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.56 LAYER met4 ;
    ANTENNAGATEAREA 5.4495 LAYER met4 ; 
    ANTENNAMAXAREACAR 28.1121 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 123.282 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.658352 LAYER via4 ;
  END rvfi_rd_wdata[5]
  PIN rvfi_rd_wdata[4] 
    ANTENNAPARTIALMETALAREA 24.4576 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 130.432 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 0.5292 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 14.7375 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 79.536 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 4.8195 LAYER met4 ; 
    ANTENNAMAXAREACAR 55.2864 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 276.691 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.951793 LAYER via4 ;
  END rvfi_rd_wdata[4]
  PIN rvfi_rd_wdata[3] 
    ANTENNAPARTIALMETALAREA 1.1743 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.728 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met3 ; 
    ANTENNAMAXAREACAR 26.4137 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 126.73 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.666667 LAYER via3 ;
    ANTENNADIFFAREA 0.5292 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 1.7748 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.936 LAYER met4 ;
    ANTENNAGATEAREA 5.4495 LAYER met4 ; 
    ANTENNAMAXAREACAR 43.092 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 212.702 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.912552 LAYER via4 ;
  END rvfi_rd_wdata[3]
  PIN rvfi_rd_wdata[2] 
    ANTENNAPARTIALMETALAREA 14.9602 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 81.184 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 1.575 LAYER met3 ; 
    ANTENNAMAXAREACAR 18.969 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 90.6756 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.565079 LAYER via3 ;
    ANTENNADIFFAREA 1.0584 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 3.6684 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 20.976 LAYER met4 ;
    ANTENNAGATEAREA 5.4495 LAYER met4 ; 
    ANTENNAMAXAREACAR 47.671 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 241.178 LAYER met4 ;
    ANTENNAMAXCUTCAR 1.05714 LAYER via4 ;
  END rvfi_rd_wdata[2]
  PIN rvfi_rd_wdata[1] 
    ANTENNADIFFAREA 1.0584 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 51.2059 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 277.712 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 4.851 LAYER met3 ; 
    ANTENNAMAXAREACAR 69.4961 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 343.442 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.659039 LAYER via3 ;
    ANTENNADIFFAREA 1.0584 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 7.1568 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 38.64 LAYER met4 ;
    ANTENNAGATEAREA 5.4495 LAYER met4 ; 
    ANTENNAMAXAREACAR 70.8094 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 350.533 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.659039 LAYER via4 ;
  END rvfi_rd_wdata[1]
  PIN rvfi_rd_wdata[0] 
    ANTENNAPARTIALMETALAREA 19.0838 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 102.224 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.7875 LAYER met3 ; 
    ANTENNAMAXAREACAR 54.6878 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 274.52 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.08 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.498413 LAYER via3 ;
    ANTENNAPARTIALMETALAREA 42.8245 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 225.664 LAYER met4 ;
    ANTENNAGATEAREA 5.4495 LAYER met4 ; 
    ANTENNAMAXAREACAR 62.5462 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 315.93 LAYER met4 ;
    ANTENNAPARTIALCUTAREA 0.64 LAYER via4 ;
    ANTENNAMAXCUTCAR 0.852892 LAYER via4 ;
    ANTENNADIFFAREA 1.0584 LAYER met5 ; 
    ANTENNAPARTIALMETALAREA 401.472 LAYER met5 ;
    ANTENNAPARTIALMETALSIDEAREA 606.048 LAYER met5 ;
    ANTENNAGATEAREA 5.4495 LAYER met5 ; 
    ANTENNAMAXAREACAR 136.218 LAYER met5 ;
    ANTENNAMAXSIDEAREACAR 427.142 LAYER met5 ;
  END rvfi_rd_wdata[0]
  PIN rvfi_mem_we 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 14.3094 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 76.312 LAYER met4 ;
  END rvfi_mem_we
  PIN rvfi_mem_addr[31] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 3.5277 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 17.4125 LAYER met2 ;
  END rvfi_mem_addr[31]
  PIN rvfi_mem_addr[30] 
    ANTENNAPARTIALMETALAREA 3.8738 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 19.208 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 1.7748 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.936 LAYER met3 ;
  END rvfi_mem_addr[30]
  PIN rvfi_mem_addr[29] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 6.4973 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 32.3785 LAYER met2 ;
  END rvfi_mem_addr[29]
  PIN rvfi_mem_addr[28] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 3.1485 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 15.6345 LAYER met2 ;
  END rvfi_mem_addr[28]
  PIN rvfi_mem_addr[27] 
    ANTENNAPARTIALMETALAREA 4.1958 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 20.818 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 1.6368 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.2 LAYER met3 ;
  END rvfi_mem_addr[27]
  PIN rvfi_mem_addr[26] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 1.9821 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 9.6845 LAYER met2 ;
  END rvfi_mem_addr[26]
  PIN rvfi_mem_addr[25] 
    ANTENNAPARTIALMETALAREA 1.8774 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 9.226 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 1.6368 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.2 LAYER met3 ;
  END rvfi_mem_addr[25]
  PIN rvfi_mem_addr[24] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 0.8544 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.552 LAYER met4 ;
  END rvfi_mem_addr[24]
  PIN rvfi_mem_addr[23] 
    ANTENNAPARTIALMETALAREA 3.1654 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 15.666 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 0.5328 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.312 LAYER met3 ;
  END rvfi_mem_addr[23]
  PIN rvfi_mem_addr[22] 
    ANTENNAPARTIALMETALAREA 3.0366 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 15.022 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 0.9468 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.52 LAYER met3 ;
  END rvfi_mem_addr[22]
  PIN rvfi_mem_addr[21] 
    ANTENNAPARTIALMETALAREA 3.2298 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 15.988 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 1.7748 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.936 LAYER met3 ;
  END rvfi_mem_addr[21]
  PIN rvfi_mem_addr[20] 
    ANTENNAPARTIALMETALAREA 2.457 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 12.124 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 0.8088 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.784 LAYER met3 ;
  END rvfi_mem_addr[20]
  PIN rvfi_mem_addr[19] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 4.6941 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 23.3625 LAYER met2 ;
  END rvfi_mem_addr[19]
  PIN rvfi_mem_addr[18] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 2.3034 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.28 LAYER met4 ;
  END rvfi_mem_addr[18]
  PIN rvfi_mem_addr[17] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 0.8544 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.552 LAYER met4 ;
  END rvfi_mem_addr[17]
  PIN rvfi_mem_addr[16] 
    ANTENNAPARTIALMETALAREA 2.9078 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 14.378 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 1.4988 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.464 LAYER met3 ;
  END rvfi_mem_addr[16]
  PIN rvfi_mem_addr[15] 
    ANTENNAPARTIALMETALAREA 3.0688 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 15.183 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 1.0848 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.256 LAYER met3 ;
  END rvfi_mem_addr[15]
  PIN rvfi_mem_addr[14] 
    ANTENNAPARTIALMETALAREA 3.0688 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 15.183 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 0.8088 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.784 LAYER met3 ;
  END rvfi_mem_addr[14]
  PIN rvfi_mem_addr[13] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 6.2364 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 33.256 LAYER met4 ;
  END rvfi_mem_addr[13]
  PIN rvfi_mem_addr[12] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 3.7209 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 18.3785 LAYER met2 ;
  END rvfi_mem_addr[12]
  PIN rvfi_mem_addr[11] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 4.0429 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 19.9885 LAYER met2 ;
  END rvfi_mem_addr[11]
  PIN rvfi_mem_addr[10] 
    ANTENNAPARTIALMETALAREA 1.9418 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 9.548 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.3268 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.88 LAYER met3 ;
  END rvfi_mem_addr[10]
  PIN rvfi_mem_addr[9] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 1.9821 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 9.6845 LAYER met2 ;
  END rvfi_mem_addr[9]
  PIN rvfi_mem_addr[8] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 6.0294 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 32.152 LAYER met4 ;
  END rvfi_mem_addr[8]
  PIN rvfi_mem_addr[7] 
    ANTENNAPARTIALMETALAREA 2.7853 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 13.7655 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 1.0848 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.256 LAYER met3 ;
  END rvfi_mem_addr[7]
  PIN rvfi_mem_addr[6] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 3.5454 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 18.904 LAYER met4 ;
  END rvfi_mem_addr[6]
  PIN rvfi_mem_addr[5] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 0.2334 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.24 LAYER met4 ;
  END rvfi_mem_addr[5]
  PIN rvfi_mem_addr[4] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 5.8224 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 31.048 LAYER met4 ;
  END rvfi_mem_addr[4]
  PIN rvfi_mem_addr[3] 
    ANTENNAPARTIALMETALAREA 1.4588 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 7.133 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 5.1558 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 27.968 LAYER met3 ;
  END rvfi_mem_addr[3]
  PIN rvfi_mem_addr[2] 
    ANTENNAPARTIALMETALAREA 4.9042 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 24.36 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 1.9128 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 10.672 LAYER met3 ;
  END rvfi_mem_addr[2]
  PIN rvfi_mem_addr[1] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 9.9624 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 53.128 LAYER met4 ;
  END rvfi_mem_addr[1]
  PIN rvfi_mem_addr[0] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 5.2014 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 27.736 LAYER met4 ;
  END rvfi_mem_addr[0]
  PIN rvfi_mem_wdata[31] 
    ANTENNAPARTIALMETALAREA 3.0366 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 15.022 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 0.8088 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.784 LAYER met3 ;
  END rvfi_mem_wdata[31]
  PIN rvfi_mem_wdata[30] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 18.6564 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 99.496 LAYER met4 ;
  END rvfi_mem_wdata[30]
  PIN rvfi_mem_wdata[29] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 2.0964 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.176 LAYER met4 ;
  END rvfi_mem_wdata[29]
  PIN rvfi_mem_wdata[28] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 19.2774 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 102.808 LAYER met4 ;
  END rvfi_mem_wdata[28]
  PIN rvfi_mem_wdata[27] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 18.6564 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 99.496 LAYER met4 ;
  END rvfi_mem_wdata[27]
  PIN rvfi_mem_wdata[26] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 5.6613 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 28.0805 LAYER met2 ;
  END rvfi_mem_wdata[26]
  PIN rvfi_mem_wdata[25] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 13.0674 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 69.688 LAYER met4 ;
  END rvfi_mem_wdata[25]
  PIN rvfi_mem_wdata[24] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 2.0964 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.176 LAYER met4 ;
  END rvfi_mem_wdata[24]
  PIN rvfi_mem_wdata[23] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 9.7554 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 52.024 LAYER met4 ;
  END rvfi_mem_wdata[23]
  PIN rvfi_mem_wdata[22] 
    ANTENNAPARTIALMETALAREA 2.296 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 11.319 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.1888 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.144 LAYER met3 ;
  END rvfi_mem_wdata[22]
  PIN rvfi_mem_wdata[21] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 6.1681 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 30.6145 LAYER met2 ;
  END rvfi_mem_wdata[21]
  PIN rvfi_mem_wdata[20] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 6.4434 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 34.36 LAYER met4 ;
  END rvfi_mem_wdata[20]
  PIN rvfi_mem_wdata[19] 
    ANTENNAPARTIALMETALAREA 1.4266 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 6.972 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 1.0848 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.256 LAYER met3 ;
  END rvfi_mem_wdata[19]
  PIN rvfi_mem_wdata[18] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 6.3041 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 31.4125 LAYER met2 ;
  END rvfi_mem_wdata[18]
  PIN rvfi_mem_wdata[17] 
    ANTENNAPARTIALMETALAREA 1.8452 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 9.065 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 1.0848 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.256 LAYER met3 ;
  END rvfi_mem_wdata[17]
  PIN rvfi_mem_wdata[16] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 7.4784 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 39.88 LAYER met4 ;
  END rvfi_mem_wdata[16]
  PIN rvfi_mem_wdata[15] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 6.8574 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 36.568 LAYER met4 ;
  END rvfi_mem_wdata[15]
  PIN rvfi_mem_wdata[14] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 6.6504 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 35.464 LAYER met4 ;
  END rvfi_mem_wdata[14]
  PIN rvfi_mem_wdata[13] 
    ANTENNAPARTIALMETALAREA 2.2316 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 10.997 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.4648 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 13.616 LAYER met3 ;
  END rvfi_mem_wdata[13]
  PIN rvfi_mem_wdata[12] 
    ANTENNAPARTIALMETALAREA 3.7128 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 18.403 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 0.9468 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.52 LAYER met3 ;
  END rvfi_mem_wdata[12]
  PIN rvfi_mem_wdata[11] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 2.5104 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.384 LAYER met4 ;
  END rvfi_mem_wdata[11]
  PIN rvfi_mem_wdata[10] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 4.6869 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 23.2085 LAYER met2 ;
  END rvfi_mem_wdata[10]
  PIN rvfi_mem_wdata[9] 
    ANTENNAPARTIALMETALAREA 1.652 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 8.099 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.7408 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.088 LAYER met3 ;
  END rvfi_mem_wdata[9]
  PIN rvfi_mem_wdata[8] 
    ANTENNAPARTIALMETALAREA 3.584 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 17.759 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 1.9128 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 10.672 LAYER met3 ;
  END rvfi_mem_wdata[8]
  PIN rvfi_mem_wdata[7] 
    ANTENNAPARTIALMETALAREA 2.135 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 10.514 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 5.0868 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 27.6 LAYER met3 ;
  END rvfi_mem_wdata[7]
  PIN rvfi_mem_wdata[6] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 4.1664 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 22.216 LAYER met4 ;
  END rvfi_mem_wdata[6]
  PIN rvfi_mem_wdata[5] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 7.0644 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 37.672 LAYER met4 ;
  END rvfi_mem_wdata[5]
  PIN rvfi_mem_wdata[4] 
    ANTENNAPARTIALMETALAREA 0.9758 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 4.718 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 1.9128 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 10.672 LAYER met3 ;
  END rvfi_mem_wdata[4]
  PIN rvfi_mem_wdata[3] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 0.6474 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.448 LAYER met4 ;
  END rvfi_mem_wdata[3]
  PIN rvfi_mem_wdata[2] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 2.6947 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 13.2475 LAYER met2 ;
  END rvfi_mem_wdata[2]
  PIN rvfi_mem_wdata[1] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 3.3384 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 17.8 LAYER met4 ;
  END rvfi_mem_wdata[1]
  PIN rvfi_mem_wdata[0] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 3.5454 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 18.904 LAYER met4 ;
  END rvfi_mem_wdata[0]
  PIN rvfi_mem_size_f3[2] 
    ANTENNAPARTIALMETALAREA 1.7808 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 8.743 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.1888 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.144 LAYER met3 ;
  END rvfi_mem_size_f3[2]
  PIN rvfi_mem_size_f3[1] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 4.3763 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 21.7735 LAYER met2 ;
  END rvfi_mem_size_f3[1]
  PIN rvfi_mem_size_f3[0] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 0.4404 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.344 LAYER met4 ;
  END rvfi_mem_size_f3[0]
  PIN perf_cycles[63] 
    ANTENNAPARTIALMETALAREA 0.3962 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.82 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.26895 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.832 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 15.0228 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 80.592 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met4 ; 
    ANTENNAMAXAREACAR 57.989 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 300.622 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.325397 LAYER via4 ;
  END perf_cycles[63]
  PIN perf_cycles[62] 
    ANTENNAPARTIALMETALAREA 7.0938 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 35.308 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.5836 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 14.72 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met3 ; 
    ANTENNAMAXAREACAR 14.2952 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 69.019 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.325397 LAYER via3 ;
  END perf_cycles[62]
  PIN perf_cycles[61] 
    ANTENNAPARTIALMETALAREA 2.2701 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 11.1895 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.5836 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 14.72 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met3 ; 
    ANTENNAMAXAREACAR 29.0737 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 142.863 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.325397 LAYER via3 ;
  END perf_cycles[61]
  PIN perf_cycles[60] 
    ANTENNAPARTIALMETALAREA 7.2226 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 35.952 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 4.4757 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 24.336 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met3 ; 
    ANTENNAMAXAREACAR 17.1181 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 84.0905 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.198413 LAYER via3 ;
  END perf_cycles[60]
  PIN perf_cycles[59] 
    ANTENNAPARTIALMETALAREA 5.7625 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 28.5285 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met2 ; 
    ANTENNAMAXAREACAR 20.7051 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 95.5 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.198413 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.4308 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 18.768 LAYER met3 ;
    ANTENNAGATEAREA 0.315 LAYER met3 ; 
    ANTENNAMAXAREACAR 31.5965 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 155.081 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.198413 LAYER via3 ;
  END perf_cycles[59]
  PIN perf_cycles[58] 
    ANTENNAPARTIALMETALAREA 6.1278 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 30.478 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.7507 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.136 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met3 ; 
    ANTENNAMAXAREACAR 12.8235 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 60.8397 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.198413 LAYER via3 ;
  END perf_cycles[58]
  PIN perf_cycles[57] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 7.4987 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 37.1595 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met2 ; 
    ANTENNAMAXAREACAR 26.2168 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 122.9 LAYER met2 ;
    ANTENNAMAXCUTCAR 0.0714286 LAYER via2 ;
  END perf_cycles[57]
  PIN perf_cycles[56] 
    ANTENNAPARTIALMETALAREA 6.05 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 29.981 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met2 ; 
    ANTENNAMAXAREACAR 21.6178 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 100.111 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.198413 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 0.3948 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.576 LAYER met3 ;
    ANTENNAGATEAREA 0.315 LAYER met3 ; 
    ANTENNAMAXAREACAR 22.8711 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 108.289 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.198413 LAYER via3 ;
  END perf_cycles[56]
  PIN perf_cycles[55] 
    ANTENNAPARTIALMETALAREA 4.7422 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 23.324 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met2 ; 
    ANTENNAMAXAREACAR 17.466 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 78.9778 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.198413 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.3268 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.88 LAYER met3 ;
    ANTENNAGATEAREA 0.315 LAYER met3 ; 
    ANTENNAMAXAREACAR 24.8527 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 119.867 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.198413 LAYER via3 ;
  END perf_cycles[55]
  PIN perf_cycles[54] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 2.5276 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 12.369 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.9138 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 21.344 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met3 ; 
    ANTENNAMAXAREACAR 18.2403 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 89.1698 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.198413 LAYER via3 ;
  END perf_cycles[54]
  PIN perf_cycles[53] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 2.6717 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 13.1425 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met2 ; 
    ANTENNAMAXAREACAR 10.893 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 46.6556 LAYER met2 ;
    ANTENNAMAXCUTCAR 0.0714286 LAYER via2 ;
  END perf_cycles[53]
  PIN perf_cycles[52] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 2.5563 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 12.5125 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 1.3608 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.728 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met3 ; 
    ANTENNAMAXAREACAR 7.22952 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 31.3667 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.198413 LAYER via3 ;
  END perf_cycles[52]
  PIN perf_cycles[51] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 6.0757 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 30.0545 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.53625 LAYER met2 ; 
    ANTENNAMAXAREACAR 14.3758 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 61.8265 LAYER met2 ;
    ANTENNAMAXCUTCAR 0.101695 LAYER via2 ;
  END perf_cycles[51]
  PIN perf_cycles[50] 
    ANTENNAPARTIALMETALAREA 3.4552 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 17.115 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 4.5255 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 25.072 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 15.6711 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 75.3513 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_cycles[50]
  PIN perf_cycles[49] 
    ANTENNAPARTIALMETALAREA 4.3826 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 21.483 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met2 ; 
    ANTENNAMAXAREACAR 30.5873 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 144.057 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.08 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 1.8936 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 11.04 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 34.5949 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 167.422 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via3 ;
  END perf_cycles[49]
  PIN perf_cycles[48] 
    ANTENNAPARTIALMETALAREA 3.1976 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 15.827 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 1.4796 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.832 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 18.5352 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 86.9746 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via3 ;
  END perf_cycles[48]
  PIN perf_cycles[47] 
    ANTENNAPARTIALMETALAREA 4.4846 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 22.036 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met2 ; 
    ANTENNAMAXAREACAR 16.6483 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 74.8889 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.198413 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 1.0848 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.256 LAYER met3 ;
    ANTENNAGATEAREA 0.315 LAYER met3 ; 
    ANTENNAMAXAREACAR 20.0921 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 94.7492 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.198413 LAYER via3 ;
  END perf_cycles[47]
  PIN perf_cycles[46] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 7.6854 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 40.984 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met4 ; 
    ANTENNAMAXAREACAR 35.0822 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 179.798 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.325397 LAYER via4 ;
  END perf_cycles[46]
  PIN perf_cycles[45] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 2.3253 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 11.3575 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.6028 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 14.352 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met3 ; 
    ANTENNAMAXAREACAR 12.5451 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 59.3063 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.198413 LAYER via3 ;
  END perf_cycles[45]
  PIN perf_cycles[44] 
    ANTENNAPARTIALMETALAREA 3.1332 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 15.505 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.5787 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 19.552 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met3 ; 
    ANTENNAMAXAREACAR 14.7232 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 71.2143 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.198413 LAYER via3 ;
  END perf_cycles[44]
  PIN perf_cycles[43] 
    ANTENNAPARTIALMETALAREA 5.5941 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 27.5835 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.22125 LAYER met2 ; 
    ANTENNAMAXAREACAR 27.5302 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 130.452 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.282486 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 5.0676 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 27.968 LAYER met3 ;
    ANTENNAGATEAREA 0.53625 LAYER met3 ; 
    ANTENNAMAXAREACAR 36.9802 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 182.607 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.325397 LAYER via3 ;
  END perf_cycles[43]
  PIN perf_cycles[42] 
    ANTENNAPARTIALMETALAREA 1.8452 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 9.065 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.7216 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.456 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 15.939 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 75.1429 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via3 ;
  END perf_cycles[42]
  PIN perf_cycles[41] 
    ANTENNAPARTIALMETALAREA 4.096 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 19.95 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met2 ; 
    ANTENNAMAXAREACAR 12.0104 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 52.3238 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 4.3968 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 23.92 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 21.3158 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 102.948 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via3 ;
  END perf_cycles[41]
  PIN perf_cycles[40] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 3.9594 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 21.112 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met4 ; 
    ANTENNAMAXAREACAR 26.9431 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 135.117 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.481481 LAYER via4 ;
  END perf_cycles[40]
  PIN perf_cycles[39] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 4.4293 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 21.7595 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met2 ; 
    ANTENNAMAXAREACAR 30.9378 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 145.876 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 1.9128 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 10.672 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 34.986 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 168.462 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_cycles[39]
  PIN perf_cycles[38] 
    ANTENNAPARTIALMETALAREA 4.9364 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 24.521 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 5.1756 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 28.064 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 15.2076 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 73.4296 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_cycles[38]
  PIN perf_cycles[37] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 1.2684 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 6.76 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.53625 LAYER met4 ; 
    ANTENNAMAXAREACAR 40.8925 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 202.611 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.537869 LAYER via4 ;
  END perf_cycles[37]
  PIN perf_cycles[36] 
    ANTENNAPARTIALMETALAREA 6.6688 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 32.914 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.22125 LAYER met2 ; 
    ANTENNAMAXAREACAR 32.3876 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 154.545 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.08 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.463277 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 4.1016 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 22.816 LAYER met3 ;
    ANTENNAGATEAREA 0.53625 LAYER met3 ; 
    ANTENNAMAXAREACAR 40.0362 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 197.092 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.463277 LAYER via3 ;
  END perf_cycles[36]
  PIN perf_cycles[35] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 12.6534 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 67.48 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met4 ; 
    ANTENNAMAXAREACAR 49.3318 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 251.213 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.481481 LAYER via4 ;
  END perf_cycles[35]
  PIN perf_cycles[34] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 8.5099 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 42.1575 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met2 ; 
    ANTENNAMAXAREACAR 56.8463 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 275.387 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 0.9468 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.52 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 58.8502 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 287.07 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_cycles[34]
  PIN perf_cycles[33] 
    ANTENNAPARTIALMETALAREA 6.6752 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 33.215 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.8646 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 21.072 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 16.634 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 79.4063 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_cycles[33]
  PIN perf_cycles[32] 
    ANTENNAPARTIALMETALAREA 7.1552 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 35.399 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met2 ; 
    ANTENNAMAXAREACAR 21.2931 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 99.2677 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.6028 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 14.352 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 26.8017 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 129.642 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via3 ;
  END perf_cycles[32]
  PIN perf_cycles[31] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 3.5299 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 17.4335 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met2 ; 
    ANTENNAMAXAREACAR 13.6175 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 60.2778 LAYER met2 ;
    ANTENNAMAXCUTCAR 0.0714286 LAYER via2 ;
  END perf_cycles[31]
  PIN perf_cycles[30] 
    ANTENNAPARTIALMETALAREA 1.974 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 9.709 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 1.7847 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.984 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met3 ; 
    ANTENNAMAXAREACAR 13.3213 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 62.3063 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.198413 LAYER via3 ;
  END perf_cycles[30]
  PIN perf_cycles[29] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 2.5563 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 12.5125 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 1.7748 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.936 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met3 ; 
    ANTENNAMAXAREACAR 8.54381 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 38.3762 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.198413 LAYER via3 ;
  END perf_cycles[29]
  PIN perf_cycles[28] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 2.8745 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 14.0385 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met2 ; 
    ANTENNAMAXAREACAR 11.5368 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 49.5 LAYER met2 ;
    ANTENNAMAXCUTCAR 0.0714286 LAYER via2 ;
  END perf_cycles[28]
  PIN perf_cycles[27] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 2.9895 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 14.5705 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.22125 LAYER met2 ; 
    ANTENNAMAXAREACAR 15.758 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 71.6362 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.282486 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 1.6368 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.2 LAYER met3 ;
    ANTENNAGATEAREA 0.53625 LAYER met3 ; 
    ANTENNAMAXAREACAR 18.8103 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 88.7923 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.282486 LAYER via3 ;
  END perf_cycles[27]
  PIN perf_cycles[26] 
    ANTENNAPARTIALMETALAREA 0.1127 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4025 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 4.4964 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 25.392 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 26.9927 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 132.527 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via3 ;
  END perf_cycles[26]
  PIN perf_cycles[25] 
    ANTENNAPARTIALMETALAREA 1.652 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 8.099 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 1.3684 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.76 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met3 ; 
    ANTENNAMAXAREACAR 14.6952 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 71.819 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via3 ;
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 5.2938 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 28.704 LAYER met4 ;
    ANTENNAGATEAREA 0.4725 LAYER met4 ; 
    ANTENNAMAXAREACAR 26.1225 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 132.568 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via4 ;
  END perf_cycles[25]
  PIN perf_cycles[24] 
    ANTENNAPARTIALMETALAREA 0.203 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.854 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.3234 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 19.136 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 29.8013 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 145.623 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via3 ;
  END perf_cycles[24]
  PIN perf_cycles[23] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 5.8761 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 28.8855 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met2 ; 
    ANTENNAMAXAREACAR 40.1238 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 191.121 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 1.3608 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.728 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 43.0038 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 207.476 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_cycles[23]
  PIN perf_cycles[22] 
    ANTENNAPARTIALMETALAREA 1.8452 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 9.065 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 1.4796 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.832 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 21.2565 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 101.06 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via3 ;
  END perf_cycles[22]
  PIN perf_cycles[21] 
    ANTENNAPARTIALMETALAREA 8.012 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 39.683 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.53625 LAYER met2 ; 
    ANTENNAMAXAREACAR 17.9867 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 79.3898 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.176287 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.5688 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 19.504 LAYER met3 ;
    ANTENNAGATEAREA 0.53625 LAYER met3 ; 
    ANTENNAMAXAREACAR 24.6418 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 115.761 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.176287 LAYER via3 ;
  END perf_cycles[21]
  PIN perf_cycles[20] 
    ANTENNAPARTIALMETALAREA 7.1062 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 35.154 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.53625 LAYER met2 ; 
    ANTENNAMAXAREACAR 15.6631 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 71.336 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.176287 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.1548 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 17.296 LAYER met3 ;
    ANTENNAGATEAREA 0.53625 LAYER met3 ; 
    ANTENNAMAXAREACAR 21.5462 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 103.59 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.176287 LAYER via3 ;
  END perf_cycles[20]
  PIN perf_cycles[19] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 9.1677 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 45.4615 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met2 ; 
    ANTENNAMAXAREACAR 61.5492 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 298.746 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.3268 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.88 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 66.4737 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 326.005 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_cycles[19]
  PIN perf_cycles[18] 
    ANTENNAPARTIALMETALAREA 8.0204 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 39.725 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met2 ; 
    ANTENNAMAXAREACAR 19.7896 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 91.7947 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 1.0848 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.256 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 22.0855 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 105.035 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via3 ;
  END perf_cycles[18]
  PIN perf_cycles[17] 
    ANTENNAPARTIALMETALAREA 4.897 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 24.206 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met2 ; 
    ANTENNAMAXAREACAR 37.7444 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 180.343 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.539683 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 0.6708 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.048 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 39.1641 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 188.91 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.539683 LAYER via3 ;
  END perf_cycles[17]
  PIN perf_cycles[16] 
    ANTENNAPARTIALMETALAREA 6.034 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 29.778 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met2 ; 
    ANTENNAMAXAREACAR 18.9202 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 87.3714 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 1.6368 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.2 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 22.3843 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 106.842 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via3 ;
  END perf_cycles[16]
  PIN perf_cycles[15] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 5.1967 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 25.7145 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 1.4988 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.464 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met3 ; 
    ANTENNAMAXAREACAR 8.12032 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 36.0143 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.198413 LAYER via3 ;
  END perf_cycles[15]
  PIN perf_cycles[14] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 5.4451 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 27.0095 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met2 ; 
    ANTENNAMAXAREACAR 19.6975 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 90.6778 LAYER met2 ;
    ANTENNAMAXCUTCAR 0.0714286 LAYER via2 ;
  END perf_cycles[14]
  PIN perf_cycles[13] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 5.8764 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 29.113 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.1888 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.144 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met3 ; 
    ANTENNAMAXAREACAR 11.5375 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 53.8302 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.198413 LAYER via3 ;
  END perf_cycles[13]
  PIN perf_cycles[12] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 5.49 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 27.181 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 0.8088 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.784 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met3 ; 
    ANTENNAMAXAREACAR 6.54317 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 27.3984 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.198413 LAYER via3 ;
  END perf_cycles[12]
  PIN perf_cycles[11] 
    ANTENNAPARTIALMETALAREA 6.643 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 33.054 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.7266 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 20.336 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.53625 LAYER met3 ; 
    ANTENNAMAXAREACAR 11.2527 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 50.0243 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.282486 LAYER via3 ;
  END perf_cycles[11]
  PIN perf_cycles[10] 
    ANTENNAPARTIALMETALAREA 7.8406 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 38.934 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.22125 LAYER met2 ; 
    ANTENNAMAXAREACAR 37.6838 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 181.754 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.282486 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 1.7847 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.984 LAYER met3 ;
    ANTENNAGATEAREA 0.53625 LAYER met3 ; 
    ANTENNAMAXAREACAR 41.012 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 200.372 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.282486 LAYER via3 ;
  END perf_cycles[10]
  PIN perf_cycles[9] 
    ANTENNAPARTIALMETALAREA 7.8084 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 38.773 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met2 ; 
    ANTENNAMAXAREACAR 52.3384 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 253.835 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 4.5447 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 24.704 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 61.9568 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 306.119 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_cycles[9]
  PIN perf_cycles[8] 
    ANTENNAPARTIALMETALAREA 7.5262 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 37.254 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met2 ; 
    ANTENNAMAXAREACAR 18.7437 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 86.5651 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.4308 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 18.768 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 26.0047 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 126.286 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via3 ;
  END perf_cycles[8]
  PIN perf_cycles[7] 
    ANTENNAPARTIALMETALAREA 5.7092 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 28.385 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 4.2687 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 23.232 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met3 ; 
    ANTENNAMAXAREACAR 16.461 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 80.5857 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.198413 LAYER via3 ;
  END perf_cycles[7]
  PIN perf_cycles[6] 
    ANTENNAPARTIALMETALAREA 5.0488 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 24.857 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met2 ; 
    ANTENNAMAXAREACAR 18.4394 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 83.8444 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.198413 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 0.8088 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.784 LAYER met3 ;
    ANTENNAGATEAREA 0.315 LAYER met3 ; 
    ANTENNAMAXAREACAR 21.007 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 99.0317 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.198413 LAYER via3 ;
  END perf_cycles[6]
  PIN perf_cycles[5] 
    ANTENNAPARTIALMETALAREA 3.101 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 15.344 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.8887 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.872 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met3 ; 
    ANTENNAMAXAREACAR 12.8394 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 61.0651 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.198413 LAYER via3 ;
  END perf_cycles[5]
  PIN perf_cycles[4] 
    ANTENNAPARTIALMETALAREA 2.487 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 12.166 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met2 ; 
    ANTENNAMAXAREACAR 10.3067 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 43.5556 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.198413 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 1.4988 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.464 LAYER met3 ;
    ANTENNAGATEAREA 0.315 LAYER met3 ; 
    ANTENNAMAXAREACAR 15.0648 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 70.4254 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.198413 LAYER via3 ;
  END perf_cycles[4]
  PIN perf_cycles[3] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 3.1393 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 15.4805 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met2 ; 
    ANTENNAMAXAREACAR 12.3279 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 53.9444 LAYER met2 ;
    ANTENNAMAXCUTCAR 0.0714286 LAYER via2 ;
  END perf_cycles[3]
  PIN perf_cycles[2] 
    ANTENNAPARTIALMETALAREA 3.0688 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 15.183 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 1.4988 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.464 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met3 ; 
    ANTENNAMAXAREACAR 11.1711 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 50.9254 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.198413 LAYER via3 ;
  END perf_cycles[2]
  PIN perf_cycles[1] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 6.8574 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 36.568 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met4 ; 
    ANTENNAMAXAREACAR 31.4943 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 162.103 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.325397 LAYER via4 ;
  END perf_cycles[1]
  PIN perf_cycles[0] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 7.2714 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 38.776 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.756 LAYER met4 ; 
    ANTENNAMAXAREACAR 15.0881 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 75.5946 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.185185 LAYER via4 ;
  END perf_cycles[0]
  PIN perf_instret[63] 
    ANTENNAPARTIALMETALAREA 3.262 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 16.149 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.1746 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 17.392 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 11.5332 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 50.4974 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_instret[63]
  PIN perf_instret[62] 
    ANTENNAPARTIALMETALAREA 4.3798 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 21.63 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met2 ; 
    ANTENNAMAXAREACAR 16.3156 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 73.6 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.198413 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.1647 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 17.344 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 23.0133 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 110.307 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_instret[62]
  PIN perf_instret[61] 
    ANTENNAPARTIALMETALAREA 2.8952 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 14.154 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.08 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 4.1115 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 22.864 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 12.1689 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 59.3831 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_instret[61]
  PIN perf_instret[60] 
    ANTENNAPARTIALMETALAREA 1.6842 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 8.26 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 5.4516 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 29.536 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 19.2067 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 93.1878 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_instret[60]
  PIN perf_instret[59] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 2.6242 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 12.95 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.3762 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 18.472 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 11.5432 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 53.4164 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_instret[59]
  PIN perf_instret[58] 
    ANTENNAPARTIALMETALAREA 1.652 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 8.099 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 6.048 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 33.192 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 25.1467 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 123.93 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via3 ;
  END perf_instret[58]
  PIN perf_instret[57] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 3.703 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 18.354 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.3268 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.88 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 11.0135 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 51.1714 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via3 ;
  END perf_instret[57]
  PIN perf_instret[56] 
    ANTENNAPARTIALMETALAREA 3.0044 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 14.861 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.26895 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.832 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 6.9597 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 37.584 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met4 ; 
    ANTENNAMAXAREACAR 38.2756 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 200.556 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via4 ;
  END perf_instret[56]
  PIN perf_instret[55] 
    ANTENNAPARTIALMETALAREA 3.9382 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 19.53 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 4.1016 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 22.816 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 16.5149 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 80.5852 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.312169 LAYER via3 ;
  END perf_instret[55]
  PIN perf_instret[54] 
    ANTENNAPARTIALMETALAREA 4.6144 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 22.911 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 4.0003 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 21.792 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met3 ; 
    ANTENNAMAXAREACAR 16.0616 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 78.3254 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.325397 LAYER via3 ;
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 1.1538 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 6.624 LAYER met4 ;
    ANTENNAGATEAREA 0.4725 LAYER met4 ; 
    ANTENNAMAXAREACAR 18.5035 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 92.3444 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via4 ;
  END perf_instret[54]
  PIN perf_instret[53] 
    ANTENNAPARTIALMETALAREA 6.8711 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 34.0865 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met2 ; 
    ANTENNAMAXAREACAR 24.2244 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 113.144 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.198413 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.1647 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 17.344 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 30.9222 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 149.851 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_instret[53]
  PIN perf_instret[52] 
    ANTENNAPARTIALMETALAREA 0.2996 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.337 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.255 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.808 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 11.0898 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 59.616 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met4 ; 
    ANTENNAMAXAREACAR 37.5332 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 192.024 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.481481 LAYER via4 ;
  END perf_instret[52]
  PIN perf_instret[51] 
    ANTENNAPARTIALMETALAREA 7.126 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 35.469 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 6.6054 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 36.16 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.69375 LAYER met3 ; 
    ANTENNAMAXAREACAR 14.9491 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 68.367 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_instret[51]
  PIN perf_instret[50] 
    ANTENNAPARTIALMETALAREA 1.652 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 8.099 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.4 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.6 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 9.6408 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 51.888 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.63 LAYER met4 ; 
    ANTENNAMAXAREACAR 41.86 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 211.778 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.714286 LAYER via4 ;
  END perf_instret[50]
  PIN perf_instret[49] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 8.748 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 43.295 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.08 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 4.2495 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 23.6 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 12.5741 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 58.9381 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_instret[49]
  PIN perf_instret[48] 
    ANTENNAPARTIALMETALAREA 7.5228 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 37.345 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met2 ; 
    ANTENNAMAXAREACAR 26.2933 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 123.489 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.198413 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.0267 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 16.608 LAYER met3 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 31.0976 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 149.851 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_instret[48]
  PIN perf_instret[47] 
    ANTENNAPARTIALMETALAREA 7.7762 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 38.612 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met2 ; 
    ANTENNAMAXAREACAR 27.0978 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 127.511 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.198413 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.1647 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 17.344 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 33.7956 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 164.218 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_instret[47]
  PIN perf_instret[46] 
    ANTENNAPARTIALMETALAREA 7.9546 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 39.263 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met2 ; 
    ANTENNAMAXAREACAR 19.5424 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 90.6899 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.1548 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 17.296 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 26.2193 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 127.295 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via3 ;
  END perf_instret[46]
  PIN perf_instret[45] 
    ANTENNAPARTIALMETALAREA 6.3559 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 31.5105 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met2 ; 
    ANTENNAMAXAREACAR 22.5889 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 104.967 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.198413 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.1647 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 17.344 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 29.2867 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 141.674 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_instret[45]
  PIN perf_instret[44] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 4.041 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 20.034 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.1647 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 17.344 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 11.5933 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 53.518 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_instret[44]
  PIN perf_instret[43] 
    ANTENNAPARTIALMETALAREA 0.1127 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4025 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.8256 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 21.344 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.69375 LAYER met3 ; 
    ANTENNAMAXAREACAR 20.0354 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 95.1014 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.258172 LAYER via3 ;
  END perf_instret[43]
  PIN perf_instret[42] 
    ANTENNAPARTIALMETALAREA 7.6067 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 37.6565 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.63 LAYER met2 ; 
    ANTENNAMAXAREACAR 14.8894 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 67.4929 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.206349 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.7068 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 20.24 LAYER met3 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 20.7732 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 99.6198 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.206349 LAYER via3 ;
  END perf_instret[42]
  PIN perf_instret[41] 
    ANTENNAPARTIALMETALAREA 6.5055 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 32.0425 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.63 LAYER met2 ; 
    ANTENNAMAXAREACAR 13.0875 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 58.5183 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.206349 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.6028 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 14.352 LAYER met3 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 17.2189 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 81.2992 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.206349 LAYER via3 ;
  END perf_instret[41]
  PIN perf_instret[40] 
    ANTENNAPARTIALMETALAREA 4.4826 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 22.036 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met2 ; 
    ANTENNAMAXAREACAR 15.2279 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 68.9418 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.1647 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 17.344 LAYER met3 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 20.2513 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 96.472 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_instret[40]
  PIN perf_instret[39] 
    ANTENNAPARTIALMETALAREA 7.1932 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 35.413 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met2 ; 
    ANTENNAMAXAREACAR 18.2696 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 82.5418 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.08 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.312169 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 4.5156 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 25.024 LAYER met3 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 25.4372 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 122.262 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_instret[39]
  PIN perf_instret[38] 
    ANTENNAPARTIALMETALAREA 5.7929 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 28.4795 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.63 LAYER met2 ; 
    ANTENNAMAXAREACAR 11.9563 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 52.8627 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.206349 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.0168 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 16.56 LAYER met3 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 16.7449 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 79.1484 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.206349 LAYER via3 ;
  END perf_instret[38]
  PIN perf_instret[37] 
    ANTENNAPARTIALMETALAREA 4.0982 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 20.202 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.69375 LAYER met2 ; 
    ANTENNAMAXAREACAR 12.0541 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 53.816 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.235875 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.1548 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 17.296 LAYER met3 ;
    ANTENNAGATEAREA 0.69375 LAYER met3 ; 
    ANTENNAMAXAREACAR 16.6015 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 78.7471 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.235875 LAYER via3 ;
  END perf_instret[37]
  PIN perf_instret[36] 
    ANTENNAPARTIALMETALAREA 5.6292 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 27.769 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.53625 LAYER met2 ; 
    ANTENNAMAXAREACAR 12.9088 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 57.5645 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.176287 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.1647 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 17.344 LAYER met3 ;
    ANTENNAGATEAREA 0.69375 LAYER met3 ; 
    ANTENNAMAXAREACAR 17.4705 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 82.5648 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_instret[36]
  PIN perf_instret[35] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 6.3889 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 31.6225 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.08 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 5.6295 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 30.96 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 16.919 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 78.6762 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_instret[35]
  PIN perf_instret[34] 
    ANTENNAPARTIALMETALAREA 2.3604 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 11.641 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 5.6394 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 31.008 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 13.6683 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 65.3619 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_instret[34]
  PIN perf_instret[33] 
    ANTENNAPARTIALMETALAREA 2.4548 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 12.103 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met2 ; 
    ANTENNAMAXAREACAR 24.0187 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 111.943 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.539683 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 4.2396 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 23.552 LAYER met3 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 30.7483 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 149.327 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.539683 LAYER via3 ;
  END perf_instret[33]
  PIN perf_instret[32] 
    ANTENNAPARTIALMETALAREA 3.103 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 15.246 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met2 ; 
    ANTENNAMAXAREACAR 12.2622 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 53.3333 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.198413 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.5787 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 19.552 LAYER met3 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 18.7846 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 88.3841 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_instret[32]
  PIN perf_instret[31] 
    ANTENNAPARTIALMETALAREA 2.8746 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 13.986 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met2 ; 
    ANTENNAMAXAREACAR 11.5371 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 49.3333 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.198413 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.3717 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 18.448 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 18.673 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 88.3767 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_instret[31]
  PIN perf_instret[30] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 2.6886 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 13.272 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.1647 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 17.344 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 12.0022 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 55.5624 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_instret[30]
  PIN perf_instret[29] 
    ANTENNAPARTIALMETALAREA 3.1134 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 15.288 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met2 ; 
    ANTENNAMAXAREACAR 12.8514 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 57.0381 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.37037 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.1548 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 17.296 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 19.5283 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 93.6434 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.37037 LAYER via3 ;
  END perf_instret[29]
  PIN perf_instret[28] 
    ANTENNAPARTIALMETALAREA 0.1127 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4025 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.8256 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 21.344 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 19.0315 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 92.9735 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.312169 LAYER via3 ;
  END perf_instret[28]
  PIN perf_instret[27] 
    ANTENNAPARTIALMETALAREA 2.2316 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 10.997 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 8.2515 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 44.944 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.69375 LAYER met3 ; 
    ANTENNAMAXAREACAR 24.5 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 117.545 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_instret[27]
  PIN perf_instret[26] 
    ANTENNAPARTIALMETALAREA 0.2996 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.337 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 7.6803 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 42.368 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 42.61 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 210.883 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via3 ;
  END perf_instret[26]
  PIN perf_instret[25] 
    ANTENNAPARTIALMETALAREA 5.7154 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 28.308 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met2 ; 
    ANTENNAMAXAREACAR 38.9956 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 187.327 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 4.2096 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 22.912 LAYER met3 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 45.6775 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 223.695 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_instret[25]
  PIN perf_instret[24] 
    ANTENNAPARTIALMETALAREA 2.0384 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 10.031 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 5.3634 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 29.536 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 18.5933 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 89.1048 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_instret[24]
  PIN perf_instret[23] 
    ANTENNAPARTIALMETALAREA 2.6732 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 13.097 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met2 ; 
    ANTENNAMAXAREACAR 11.5322 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 46.9667 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.198413 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 5.6295 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 30.96 LAYER met3 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 24.8392 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 120.197 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via3 ;
  END perf_instret[23]
  PIN perf_instret[22] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 3.5194 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 17.059 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met2 ; 
    ANTENNAMAXAREACAR 13.5841 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 59.0889 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.08 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.325397 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 4.6536 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 25.76 LAYER met3 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 20.9708 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 99.9778 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_instret[22]
  PIN perf_instret[21] 
    ANTENNAPARTIALMETALAREA 2.1734 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 10.598 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.22125 LAYER met2 ; 
    ANTENNAMAXAREACAR 12.3019 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 55.209 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.282486 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.9735 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 22.128 LAYER met3 ;
    ANTENNAGATEAREA 0.69375 LAYER met3 ; 
    ANTENNAMAXAREACAR 19.6242 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 90.4851 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_instret[21]
  PIN perf_instret[20] 
    ANTENNAPARTIALMETALAREA 0.1127 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4025 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 6.8715 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 37.584 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.69375 LAYER met3 ; 
    ANTENNAMAXAREACAR 20.6154 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 100.631 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_instret[20]
  PIN perf_instret[19] 
    ANTENNAPARTIALMETALAREA 0.8792 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 4.235 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 4.3875 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 24.336 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 18.3706 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 88.1228 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_instret[19]
  PIN perf_instret[18] 
    ANTENNAPARTIALMETALAREA 2.6977 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 13.2195 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met2 ; 
    ANTENNAMAXAREACAR 19.9435 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 91.654 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.3367 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.928 LAYER met3 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 23.6525 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 112.175 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_instret[18]
  PIN perf_instret[17] 
    ANTENNAPARTIALMETALAREA 5.7634 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 28.322 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met2 ; 
    ANTENNAMAXAREACAR 16.7066 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 76.1058 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.3027 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 18.08 LAYER met3 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 21.9489 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 104.804 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_instret[17]
  PIN perf_instret[16] 
    ANTENNAPARTIALMETALAREA 1.8452 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 9.065 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.255 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.808 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 2.1888 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.144 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.63 LAYER met4 ; 
    ANTENNAMAXAREACAR 17.0171 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 83.6921 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.460317 LAYER via4 ;
  END perf_instret[16]
  PIN perf_instret[15] 
    ANTENNAPARTIALMETALAREA 5.2906 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 26.292 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 4.8306 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 26.224 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 17.266 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 83.2275 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_instret[15]
  PIN perf_instret[14] 
    ANTENNAPARTIALMETALAREA 4.363 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 21.546 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met2 ; 
    ANTENNAMAXAREACAR 16.2622 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 73.3333 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.198413 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.3027 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 18.08 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 23.2521 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 111.598 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_instret[14]
  PIN perf_instret[13] 
    ANTENNAPARTIALMETALAREA 4.7432 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 23.555 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 4.8306 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 26.224 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 15.2413 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 73.5608 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_instret[13]
  PIN perf_instret[12] 
    ANTENNAPARTIALMETALAREA 6.5204 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 32.333 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met2 ; 
    ANTENNAMAXAREACAR 46.3359 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 223.571 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.9927 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 21.76 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 54.786 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 269.624 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_instret[12]
  PIN perf_instret[11] 
    ANTENNAPARTIALMETALAREA 8.7244 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 43.127 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.69375 LAYER met2 ; 
    ANTENNAMAXAREACAR 16.9744 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 78.5854 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.261047 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.6028 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 14.352 LAYER met3 ;
    ANTENNAGATEAREA 0.69375 LAYER met3 ; 
    ANTENNAMAXAREACAR 20.7261 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 99.273 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.261047 LAYER via3 ;
  END perf_instret[11]
  PIN perf_instret[10] 
    ANTENNAPARTIALMETALAREA 9.0746 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 44.996 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.53625 LAYER met2 ; 
    ANTENNAMAXAREACAR 19.3338 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 89.6894 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.176287 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.3717 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 18.448 LAYER met3 ;
    ANTENNAGATEAREA 0.69375 LAYER met3 ; 
    ANTENNAMAXAREACAR 24.1939 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 116.281 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_instret[10]
  PIN perf_instret[9] 
    ANTENNAPARTIALMETALAREA 6.1922 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 30.8 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 6.2214 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 34.592 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 21.526 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 104.81 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via3 ;
  END perf_instret[9]
  PIN perf_instret[8] 
    ANTENNAPARTIALMETALAREA 0.1127 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4025 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.538 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.336 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 14.1948 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 76.176 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.63 LAYER met4 ; 
    ANTENNAMAXAREACAR 38.0384 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 194.505 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.460317 LAYER via4 ;
  END perf_instret[8]
  PIN perf_instret[7] 
    ANTENNAPARTIALMETALAREA 7.1134 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 35.245 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.08 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 4.8015 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 26.544 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 13.8654 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 67.5714 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_instret[7]
  PIN perf_instret[6] 
    ANTENNAPARTIALMETALAREA 2.779 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 13.734 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 6.3195 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 34.64 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 24.599 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 121.257 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_instret[6]
  PIN perf_instret[5] 
    ANTENNAPARTIALMETALAREA 4.6815 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 23.1385 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met2 ; 
    ANTENNAMAXAREACAR 17.2733 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 78.3889 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.198413 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.3717 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 18.448 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 24.4092 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 117.432 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_instret[5]
  PIN perf_instret[4] 
    ANTENNAPARTIALMETALAREA 2.135 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 10.514 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.6127 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 14.4 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 11.066 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 51.6254 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via3 ;
  END perf_instret[4]
  PIN perf_instret[3] 
    ANTENNAPARTIALMETALAREA 3.5105 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 17.1605 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met2 ; 
    ANTENNAMAXAREACAR 10.1369 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 43.9122 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.1548 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 17.296 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 16.8138 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 80.5175 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via3 ;
  END perf_instret[3]
  PIN perf_instret[2] 
    ANTENNAPARTIALMETALAREA 3.3843 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 16.5445 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met2 ; 
    ANTENNAMAXAREACAR 9.86984 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 42.6085 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.2928 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 18.032 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 16.8387 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 80.7714 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via3 ;
  END perf_instret[2]
  PIN perf_instret[1] 
    ANTENNAPARTIALMETALAREA 2.7146 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 13.412 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.3861 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 18.52 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 11.7552 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 54.4735 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_instret[1]
  PIN perf_instret[0] 
    ANTENNAPARTIALMETALAREA 3.9682 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 19.572 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met2 ; 
    ANTENNAMAXAREACAR 10.1178 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 44.7048 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.132275 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.1647 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 17.344 LAYER met3 ;
    ANTENNAGATEAREA 0.7875 LAYER met3 ; 
    ANTENNAMAXAREACAR 14.1364 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 66.7289 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.198413 LAYER via3 ;
  END perf_instret[0]
  PIN perf_ctrl_instrs[63] 
    ANTENNAPARTIALMETALAREA 0.5894 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.786 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.745 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.44 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 8.1918 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 44.16 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met4 ; 
    ANTENNAMAXAREACAR 27.9386 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 141.539 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.312169 LAYER via4 ;
  END perf_ctrl_instrs[63]
  PIN perf_ctrl_instrs[62] 
    ANTENNAPARTIALMETALAREA 4.0026 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 19.852 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.3367 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.928 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 10.1583 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 45.654 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via3 ;
  END perf_ctrl_instrs[62]
  PIN perf_ctrl_instrs[61] 
    ANTENNAPARTIALMETALAREA 3.9382 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 19.53 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.4905 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 19.552 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 11.9111 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 55.7323 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_ctrl_instrs[61]
  PIN perf_ctrl_instrs[60] 
    ANTENNAPARTIALMETALAREA 3.4936 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 17.199 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met2 ; 
    ANTENNAMAXAREACAR 13.5022 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 59.5333 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.198413 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.7507 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.136 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 19.3238 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 91.5672 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_ctrl_instrs[60]
  PIN perf_ctrl_instrs[59] 
    ANTENNAPARTIALMETALAREA 2.8434 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 14.056 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 5.1756 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 28.064 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 14.7448 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 70.7693 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_ctrl_instrs[59]
  PIN perf_ctrl_instrs[58] 
    ANTENNAPARTIALMETALAREA 3.1141 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 15.1935 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met2 ; 
    ANTENNAMAXAREACAR 9.6218 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 40.1302 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.7408 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.088 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 15.4224 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 72.0624 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via3 ;
  END perf_ctrl_instrs[58]
  PIN perf_ctrl_instrs[57] 
    ANTENNAPARTIALMETALAREA 4.2438 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 20.832 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met2 ; 
    ANTENNAMAXAREACAR 15.8838 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 71.0667 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.198413 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.7507 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.136 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 21.7054 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 103.101 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_ctrl_instrs[57]
  PIN perf_ctrl_instrs[56] 
    ANTENNAPARTIALMETALAREA 1.8452 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 9.065 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.6127 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 14.4 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 10.6743 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 48.4286 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via3 ;
  END perf_ctrl_instrs[56]
  PIN perf_ctrl_instrs[55] 
    ANTENNAPARTIALMETALAREA 0.8792 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 4.235 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 5.6295 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 30.96 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 30.8565 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 151.632 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via3 ;
  END perf_ctrl_instrs[55]
  PIN perf_ctrl_instrs[54] 
    ANTENNAPARTIALMETALAREA 3.262 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 16.149 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.9927 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 21.76 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 13.2576 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 62.2868 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via3 ;
  END perf_ctrl_instrs[54]
  PIN perf_ctrl_instrs[53] 
    ANTENNAPARTIALMETALAREA 2.2638 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 11.158 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.4747 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 13.664 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 10.1437 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 45.6783 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via3 ;
  END perf_ctrl_instrs[53]
  PIN perf_ctrl_instrs[52] 
    ANTENNAPARTIALMETALAREA 2.8818 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 14.14 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met2 ; 
    ANTENNAMAXAREACAR 9.13016 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 37.9005 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.6028 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 14.352 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 14.6387 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 68.2751 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via3 ;
  END perf_ctrl_instrs[52]
  PIN perf_ctrl_instrs[51] 
    ANTENNAPARTIALMETALAREA 0.1127 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4025 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 5.4915 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 30.224 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.69375 LAYER met3 ; 
    ANTENNAMAXAREACAR 20.0451 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 96.1559 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.354078 LAYER via3 ;
  END perf_ctrl_instrs[51]
  PIN perf_ctrl_instrs[50] 
    ANTENNAPARTIALMETALAREA 0.2996 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.337 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 5.2056 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 28.704 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 17.8368 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 85.381 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.269841 LAYER via3 ;
  END perf_ctrl_instrs[50]
  PIN perf_ctrl_instrs[49] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 4.2787 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 20.8985 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met2 ; 
    ANTENNAMAXAREACAR 29.9276 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 140.346 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.0267 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 16.608 LAYER met3 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 34.7319 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 166.708 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_ctrl_instrs[49]
  PIN perf_ctrl_instrs[48] 
    ANTENNAPARTIALMETALAREA 2.7971 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 13.5835 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met2 ; 
    ANTENNAMAXAREACAR 12.5776 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 55.4085 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.37037 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.4747 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 13.664 LAYER met3 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 16.5057 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 77.0974 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_ctrl_instrs[48]
  PIN perf_ctrl_instrs[47] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 2.6207 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 12.8345 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.5787 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 19.552 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 14.5511 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 67.9989 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_ctrl_instrs[47]
  PIN perf_ctrl_instrs[46] 
    ANTENNAPARTIALMETALAREA 3.1528 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 15.442 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.08 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 7.0095 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 38.32 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 18.626 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 92.4751 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_ctrl_instrs[46]
  PIN perf_ctrl_instrs[45] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 3.88 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 19.131 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.5787 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 19.552 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 14.2073 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 66.8799 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_ctrl_instrs[45]
  PIN perf_ctrl_instrs[44] 
    ANTENNAPARTIALMETALAREA 3.2942 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 16.31 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.7507 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.136 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 11.4717 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 52.7418 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via3 ;
  END perf_ctrl_instrs[44]
  PIN perf_ctrl_instrs[43] 
    ANTENNAPARTIALMETALAREA 2.0062 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 9.87 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 5.6103 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 31.328 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.69375 LAYER met3 ; 
    ANTENNAMAXAREACAR 16.4418 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 77.6432 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via3 ;
  END perf_ctrl_instrs[43]
  PIN perf_ctrl_instrs[42] 
    ANTENNAPARTIALMETALAREA 0.1127 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4025 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 7.5423 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 41.632 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 28.1376 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 138.448 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via3 ;
  END perf_ctrl_instrs[42]
  PIN perf_ctrl_instrs[41] 
    ANTENNAPARTIALMETALAREA 3.6328 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 17.787 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.63 LAYER met2 ; 
    ANTENNAMAXAREACAR 8.79746 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 36.2079 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.206349 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.7408 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.088 LAYER met3 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 13.1479 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 60.1571 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.206349 LAYER via3 ;
  END perf_ctrl_instrs[41]
  PIN perf_ctrl_instrs[40] 
    ANTENNAPARTIALMETALAREA 2.3344 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 11.403 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met2 ; 
    ANTENNAMAXAREACAR 19.3359 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 88.5714 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 6.5556 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 35.424 LAYER met3 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 29.7416 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 144.8 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_ctrl_instrs[40]
  PIN perf_ctrl_instrs[39] 
    ANTENNAPARTIALMETALAREA 0.1127 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4025 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 6.9804 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 38.64 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 23.1831 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 113.278 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_ctrl_instrs[39]
  PIN perf_ctrl_instrs[38] 
    ANTENNAPARTIALMETALAREA 3.6484 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 18.081 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 5.7483 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 32.064 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 19.6132 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 95.1619 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via3 ;
  END perf_ctrl_instrs[38]
  PIN perf_ctrl_instrs[37] 
    ANTENNAPARTIALMETALAREA 8.1078 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 40.054 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.69375 LAYER met2 ; 
    ANTENNAMAXAREACAR 14.7328 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 66.4993 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.200515 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 1.9128 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 10.672 LAYER met3 ;
    ANTENNAGATEAREA 0.69375 LAYER met3 ; 
    ANTENNAMAXAREACAR 17.49 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 81.8824 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.200515 LAYER via3 ;
  END perf_ctrl_instrs[37]
  PIN perf_ctrl_instrs[36] 
    ANTENNAPARTIALMETALAREA 5.007 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 24.766 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.22125 LAYER met2 ; 
    ANTENNAMAXAREACAR 24.8766 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 117.718 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.282486 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 6.2106 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 33.584 LAYER met3 ;
    ANTENNAGATEAREA 0.69375 LAYER met3 ; 
    ANTENNAMAXAREACAR 33.8288 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 166.127 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_ctrl_instrs[36]
  PIN perf_ctrl_instrs[35] 
    ANTENNAPARTIALMETALAREA 3.1654 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 15.666 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 6.9105 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 37.312 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 18.2897 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 88.5937 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_ctrl_instrs[35]
  PIN perf_ctrl_instrs[34] 
    ANTENNAPARTIALMETALAREA 2.6824 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 13.251 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 6.8814 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 37.632 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 15.7457 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 75.6222 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_ctrl_instrs[34]
  PIN perf_ctrl_instrs[33] 
    ANTENNAPARTIALMETALAREA 1.9481 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 9.5795 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.1836 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 17.44 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 14.4433 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 67.6624 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_ctrl_instrs[33]
  PIN perf_ctrl_instrs[32] 
    ANTENNAPARTIALMETALAREA 2.779 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 13.734 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met2 ; 
    ANTENNAMAXAREACAR 20.6756 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 95.1746 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.7507 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.136 LAYER met3 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 25.0417 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 119.2 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_ctrl_instrs[32]
  PIN perf_ctrl_instrs[31] 
    ANTENNAPARTIALMETALAREA 5.4712 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 27.034 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.08 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 4.8015 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 26.544 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 13.953 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 67.5524 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_ctrl_instrs[31]
  PIN perf_ctrl_instrs[30] 
    ANTENNAPARTIALMETALAREA 5.9573 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 29.2915 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met2 ; 
    ANTENNAMAXAREACAR 15.6392 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 69.9672 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.6028 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 14.352 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 21.1477 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 100.342 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via3 ;
  END perf_ctrl_instrs[30]
  PIN perf_ctrl_instrs[29] 
    ANTENNAPARTIALMETALAREA 4.7754 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 23.716 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.8887 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.872 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 10.5283 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 48.1217 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via3 ;
  END perf_ctrl_instrs[29]
  PIN perf_ctrl_instrs[28] 
    ANTENNAPARTIALMETALAREA 5.8672 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 28.959 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met2 ; 
    ANTENNAMAXAREACAR 15.4485 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 69.2635 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.8788 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.824 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 21.5412 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 102.753 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via3 ;
  END perf_ctrl_instrs[28]
  PIN perf_ctrl_instrs[27] 
    ANTENNAPARTIALMETALAREA 6.9972 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 34.825 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 6.7335 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 36.848 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.69375 LAYER met3 ; 
    ANTENNAMAXAREACAR 16.3839 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 78.274 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.312169 LAYER via3 ;
  END perf_ctrl_instrs[27]
  PIN perf_ctrl_instrs[26] 
    ANTENNAPARTIALMETALAREA 8.0576 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 39.858 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met2 ; 
    ANTENNAMAXAREACAR 27.9911 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 131.467 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.08 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.325397 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 6.7335 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 36.848 LAYER met3 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 38.6792 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 189.956 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_ctrl_instrs[26]
  PIN perf_ctrl_instrs[25] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 8.0043 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 39.6445 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met2 ; 
    ANTENNAMAXAREACAR 55.3352 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 267.883 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.8788 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.824 LAYER met3 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 59.9048 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 293 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_ctrl_instrs[25]
  PIN perf_ctrl_instrs[24] 
    ANTENNAPARTIALMETALAREA 8.0856 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 39.998 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met2 ; 
    ANTENNAMAXAREACAR 28.08 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 131.911 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.08 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.325397 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 4.6635 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 25.808 LAYER met3 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 35.4824 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 172.876 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_ctrl_instrs[24]
  PIN perf_ctrl_instrs[23] 
    ANTENNAPARTIALMETALAREA 10.0252 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 49.749 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.63 LAYER met2 ; 
    ANTENNAMAXAREACAR 18.9589 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 86.9413 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.206349 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.7408 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.088 LAYER met3 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 23.3094 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 110.89 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.206349 LAYER via3 ;
  END perf_ctrl_instrs[23]
  PIN perf_ctrl_instrs[22] 
    ANTENNAPARTIALMETALAREA 6.456 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 32.011 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met2 ; 
    ANTENNAMAXAREACAR 44.3321 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 213.346 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.2736 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 18.4 LAYER met3 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 49.5283 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 242.552 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_ctrl_instrs[22]
  PIN perf_ctrl_instrs[21] 
    ANTENNAPARTIALMETALAREA 9.5764 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 47.495 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.53625 LAYER met2 ; 
    ANTENNAMAXAREACAR 21.7921 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 103.154 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.277982 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.7507 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.136 LAYER met3 ;
    ANTENNAGATEAREA 0.69375 LAYER met3 ; 
    ANTENNAMAXAREACAR 25.7571 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 124.972 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_ctrl_instrs[21]
  PIN perf_ctrl_instrs[20] 
    ANTENNAPARTIALMETALAREA 9.599 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 47.565 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met2 ; 
    ANTENNAMAXAREACAR 32.8844 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 155.933 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.08 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.325397 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.6975 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 20.656 LAYER met3 ;
    ANTENNAGATEAREA 0.69375 LAYER met3 ; 
    ANTENNAMAXAREACAR 38.2142 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 185.708 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_ctrl_instrs[20]
  PIN perf_ctrl_instrs[19] 
    ANTENNAPARTIALMETALAREA 1.8452 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 9.065 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.26895 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.832 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 5.5008 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 29.808 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.63 LAYER met4 ; 
    ANTENNAMAXAREACAR 19.3119 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 94.3143 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.460317 LAYER via4 ;
  END perf_ctrl_instrs[19]
  PIN perf_ctrl_instrs[18] 
    ANTENNAPARTIALMETALAREA 0.1127 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4025 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 6.9504 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 38 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 46.5625 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 229.505 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via3 ;
  END perf_ctrl_instrs[18]
  PIN perf_ctrl_instrs[17] 
    ANTENNAPARTIALMETALAREA 6.3762 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 31.612 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met2 ; 
    ANTENNAMAXAREACAR 16.5257 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 74.8783 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.7408 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.088 LAYER met3 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 20.8762 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 98.8275 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_ctrl_instrs[17]
  PIN perf_ctrl_instrs[16] 
    ANTENNAPARTIALMETALAREA 6.8481 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 33.8485 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met2 ; 
    ANTENNAMAXAREACAR 17.5244 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 79.6116 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.7408 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.088 LAYER met3 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 21.8749 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 103.561 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_ctrl_instrs[16]
  PIN perf_ctrl_instrs[15] 
    ANTENNAPARTIALMETALAREA 0.9758 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 4.718 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.331 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.232 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 8.3988 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 45.264 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met4 ; 
    ANTENNAMAXAREACAR 28.3812 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 143.473 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.481481 LAYER via4 ;
  END perf_ctrl_instrs[15]
  PIN perf_ctrl_instrs[14] 
    ANTENNAPARTIALMETALAREA 6.778 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 33.621 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met2 ; 
    ANTENNAMAXAREACAR 23.9289 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 111.667 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.198413 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.7507 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.136 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 29.7505 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 143.701 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_ctrl_instrs[14]
  PIN perf_ctrl_instrs[13] 
    ANTENNAPARTIALMETALAREA 4.5178 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 22.428 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.5886 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 19.6 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 12.8994 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 60.337 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_ctrl_instrs[13]
  PIN perf_ctrl_instrs[12] 
    ANTENNAPARTIALMETALAREA 5.9093 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 29.2775 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met2 ; 
    ANTENNAMAXAREACAR 15.5376 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 69.9376 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.7408 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.088 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 21.3382 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 101.87 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via3 ;
  END perf_ctrl_instrs[12]
  PIN perf_ctrl_instrs[11] 
    ANTENNAPARTIALMETALAREA 1.8774 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 9.226 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.26895 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.832 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 6.5358 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 35.328 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.69375 LAYER met4 ; 
    ANTENNAMAXAREACAR 23.6498 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 117.443 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.31583 LAYER via4 ;
  END perf_ctrl_instrs[11]
  PIN perf_ctrl_instrs[10] 
    ANTENNAPARTIALMETALAREA 8.3788 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 41.517 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.53625 LAYER met2 ; 
    ANTENNAMAXAREACAR 18.0362 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 83.2018 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.176287 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.5787 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 19.552 LAYER met3 ;
    ANTENNAGATEAREA 0.69375 LAYER met3 ; 
    ANTENNAMAXAREACAR 23.1947 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 111.385 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_ctrl_instrs[10]
  PIN perf_ctrl_instrs[9] 
    ANTENNAPARTIALMETALAREA 4.55 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 22.589 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.6876 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 20.608 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 14.7219 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 69.1746 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.269841 LAYER via3 ;
  END perf_ctrl_instrs[9]
  PIN perf_ctrl_instrs[8] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 13.6884 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 73 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.63 LAYER met4 ; 
    ANTENNAMAXAREACAR 33.1825 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 167.283 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.460317 LAYER via4 ;
  END perf_ctrl_instrs[8]
  PIN perf_ctrl_instrs[7] 
    ANTENNAPARTIALMETALAREA 4.5178 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 22.428 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met2 ; 
    ANTENNAMAXAREACAR 31.7156 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 150.375 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.5787 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 19.552 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 39.2895 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 191.754 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_ctrl_instrs[7]
  PIN perf_ctrl_instrs[6] 
    ANTENNAPARTIALMETALAREA 6.0585 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 29.9005 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met2 ; 
    ANTENNAMAXAREACAR 15.8533 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 71.2561 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.7408 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.088 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 21.654 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 103.188 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via3 ;
  END perf_ctrl_instrs[6]
  PIN perf_ctrl_instrs[5] 
    ANTENNAPARTIALMETALAREA 5.2262 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 25.97 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 5.1066 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 27.696 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 15.0898 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 72.3603 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_ctrl_instrs[5]
  PIN perf_ctrl_instrs[4] 
    ANTENNAPARTIALMETALAREA 4.6099 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 22.6625 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met2 ; 
    ANTENNAMAXAREACAR 32.3003 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 151.863 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.7484 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.12 LAYER met3 ;
    ANTENNAGATEAREA 0.1575 LAYER met3 ; 
    ANTENNAMAXAREACAR 49.7505 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 247.863 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via3 ;
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 2.3958 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.248 LAYER met4 ;
    ANTENNAGATEAREA 0.4725 LAYER met4 ; 
    ANTENNAMAXAREACAR 54.821 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 275.902 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via4 ;
  END perf_ctrl_instrs[4]
  PIN perf_ctrl_instrs[3] 
    ANTENNAPARTIALMETALAREA 7.8456 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 38.836 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met2 ; 
    ANTENNAMAXAREACAR 19.6356 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 90.1672 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.7408 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.088 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 25.4362 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 122.099 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via3 ;
  END perf_ctrl_instrs[3]
  PIN perf_ctrl_instrs[2] 
    ANTENNAPARTIALMETALAREA 6.5973 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 32.6095 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met2 ; 
    ANTENNAMAXAREACAR 16.9937 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 76.9894 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.7408 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.088 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 22.7943 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 108.922 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via3 ;
  END perf_ctrl_instrs[2]
  PIN perf_ctrl_instrs[1] 
    ANTENNAPARTIALMETALAREA 5.1542 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 25.487 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met2 ; 
    ANTENNAMAXAREACAR 18.774 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 85.8444 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.198413 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 5.0277 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 27.28 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 29.4146 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 143.58 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_ctrl_instrs[1]
  PIN perf_ctrl_instrs[0] 
    ANTENNAPARTIALMETALAREA 1.652 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 8.099 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 4.9296 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 27.232 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.7875 LAYER met3 ; 
    ANTENNAMAXAREACAR 22.4884 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 109.433 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.216931 LAYER via3 ;
  END perf_ctrl_instrs[0]
  PIN perf_mispredicts[63] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 4.3098 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 21.147 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.7507 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.136 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 11.4671 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 49.8783 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_mispredicts[63]
  PIN perf_mispredicts[62] 
    ANTENNAPARTIALMETALAREA 5.5831 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 27.6465 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met2 ; 
    ANTENNAMAXAREACAR 38.4794 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 183.508 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.7507 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.136 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 44.301 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 215.542 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_mispredicts[62]
  PIN perf_mispredicts[61] 
    ANTENNAPARTIALMETALAREA 1.9481 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 9.5795 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.255 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.808 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 7.7778 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 41.952 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met4 ; 
    ANTENNAMAXAREACAR 31.5844 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 160.973 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.481481 LAYER via4 ;
  END perf_mispredicts[61]
  PIN perf_mispredicts[60] 
    ANTENNAPARTIALMETALAREA 5.4194 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 26.936 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met2 ; 
    ANTENNAMAXAREACAR 37.44 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 178.997 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 5.0277 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 27.28 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 48.0806 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 236.732 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_mispredicts[60]
  PIN perf_mispredicts[59] 
    ANTENNAPARTIALMETALAREA 0.1127 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4025 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 5.0775 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 28.016 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 34.9327 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 172.049 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_mispredicts[59]
  PIN perf_mispredicts[58] 
    ANTENNAPARTIALMETALAREA 1.6842 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 8.26 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.607 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.704 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 4.6728 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 25.392 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met4 ; 
    ANTENNAMAXAREACAR 19.8726 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 98.5079 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.312169 LAYER via4 ;
  END perf_mispredicts[58]
  PIN perf_mispredicts[57] 
    ANTENNAPARTIALMETALAREA 2.3282 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 11.48 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.7606 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.184 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 11.3648 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 52.0799 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_mispredicts[57]
  PIN perf_mispredicts[56] 
    ANTENNAPARTIALMETALAREA 1.9096 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 9.387 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.8887 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.872 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 11.3592 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 52.0476 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via3 ;
  END perf_mispredicts[56]
  PIN perf_mispredicts[55] 
    ANTENNAPARTIALMETALAREA 3.5132 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 17.136 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met2 ; 
    ANTENNAMAXAREACAR 13.5644 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 59.3333 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.08 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.325397 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.4116 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 19.136 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 20.7848 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 99.8328 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_mispredicts[55]
  PIN perf_mispredicts[54] 
    ANTENNAPARTIALMETALAREA 4.7514 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 23.247 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met2 ; 
    ANTENNAMAXAREACAR 13.087 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 57.1746 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.7408 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.088 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 18.8876 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 89.1069 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via3 ;
  END perf_mispredicts[54]
  PIN perf_mispredicts[53] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 6.4175 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 31.6575 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.08 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 4.9986 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 27.6 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 14.6063 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 70.1873 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_mispredicts[53]
  PIN perf_mispredicts[52] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 14.1024 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 75.208 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met4 ; 
    ANTENNAMAXAREACAR 41.0907 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 210.639 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.481481 LAYER via4 ;
  END perf_mispredicts[52]
  PIN perf_mispredicts[51] 
    ANTENNAPARTIALMETALAREA 8.897 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 44.324 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 5.3089 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 28.776 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.22125 LAYER met3 ; 
    ANTENNAMAXAREACAR 26.7821 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 138.262 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.463277 LAYER via3 ;
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 5.0967 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 27.648 LAYER met4 ;
    ANTENNAGATEAREA 0.69375 LAYER met4 ; 
    ANTENNAMAXAREACAR 34.1287 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 178.115 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via4 ;
  END perf_mispredicts[51]
  PIN perf_mispredicts[50] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 17.0004 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 90.664 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.63 LAYER met4 ; 
    ANTENNAMAXAREACAR 36.9368 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 188.752 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.460317 LAYER via4 ;
  END perf_mispredicts[50]
  PIN perf_mispredicts[49] 
    ANTENNAPARTIALMETALAREA 9.1868 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 45.773 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 4.1016 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 22.816 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 15.8481 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 74.8294 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.269841 LAYER via3 ;
  END perf_mispredicts[49]
  PIN perf_mispredicts[48] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 10.1134 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 50.288 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met2 ; 
    ANTENNAMAXAREACAR 68.9968 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 336.127 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.539683 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.7408 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.088 LAYER met3 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 73.3473 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 360.076 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.539683 LAYER via3 ;
  END perf_mispredicts[48]
  PIN perf_mispredicts[47] 
    ANTENNAPARTIALMETALAREA 8.0855 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 40.0505 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met2 ; 
    ANTENNAMAXAREACAR 20.1433 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 92.7376 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.0508 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 11.408 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 24.4836 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 116.881 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via3 ;
  END perf_mispredicts[47]
  PIN perf_mispredicts[46] 
    ANTENNAPARTIALMETALAREA 4.7432 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 23.555 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.4747 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 13.664 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 11.8815 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 54.3672 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via3 ;
  END perf_mispredicts[46]
  PIN perf_mispredicts[45] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 10.5834 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 56.44 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met4 ; 
    ANTENNAMAXAREACAR 33.6869 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 171.526 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.481481 LAYER via4 ;
  END perf_mispredicts[45]
  PIN perf_mispredicts[44] 
    ANTENNAPARTIALMETALAREA 6.643 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 33.054 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 4.1406 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 22.544 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 13.2698 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 62.5788 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_mispredicts[44]
  PIN perf_mispredicts[43] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 12.7363 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 63.3045 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.22125 LAYER met2 ; 
    ANTENNAMAXAREACAR 59.8113 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 291.903 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.282486 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.6028 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 14.352 LAYER met3 ;
    ANTENNAGATEAREA 0.69375 LAYER met3 ; 
    ANTENNAMAXAREACAR 63.5631 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 312.59 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.282486 LAYER via3 ;
  END perf_mispredicts[43]
  PIN perf_mispredicts[42] 
    ANTENNAPARTIALMETALAREA 1.7486 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 8.582 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.4 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.6 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 12.3318 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 66.24 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.63 LAYER met4 ; 
    ANTENNAMAXAREACAR 30.9475 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 157.255 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.333333 LAYER via4 ;
  END perf_mispredicts[42]
  PIN perf_mispredicts[41] 
    ANTENNAPARTIALMETALAREA 7.609 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 37.884 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met2 ; 
    ANTENNAMAXAREACAR 51.0724 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 248.19 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.5595 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 19.92 LAYER met3 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 56.7224 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 279.81 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via3 ;
  END perf_mispredicts[41]
  PIN perf_mispredicts[40] 
    ANTENNAPARTIALMETALAREA 1.7486 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 8.582 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.1356 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 17.664 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 25.4244 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 123.176 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.269841 LAYER via3 ;
  END perf_mispredicts[40]
  PIN perf_mispredicts[39] 
    ANTENNAPARTIALMETALAREA 2.5858 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 12.768 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 5.6103 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 31.328 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 15.8797 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 74.2159 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_mispredicts[39]
  PIN perf_mispredicts[38] 
    ANTENNAPARTIALMETALAREA 7.4158 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 36.918 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 4.5255 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 25.072 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 38.9795 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 190.521 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via3 ;
  END perf_mispredicts[38]
  PIN perf_mispredicts[37] 
    ANTENNAPARTIALMETALAREA 10.7386 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 53.424 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.22125 LAYER met2 ; 
    ANTENNAMAXAREACAR 50.5311 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 246.843 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.282486 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 4.5156 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 25.024 LAYER met3 ;
    ANTENNAGATEAREA 0.69375 LAYER met3 ; 
    ANTENNAMAXAREACAR 57.04 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 282.914 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.312169 LAYER via3 ;
  END perf_mispredicts[37]
  PIN perf_mispredicts[36] 
    ANTENNAPARTIALMETALAREA 11.7752 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 58.499 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.53625 LAYER met2 ; 
    ANTENNAMAXAREACAR 24.3698 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 114.87 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.176287 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 4.4067 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 23.968 LAYER met3 ;
    ANTENNAGATEAREA 0.69375 LAYER met3 ; 
    ANTENNAMAXAREACAR 30.7218 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 149.418 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_mispredicts[36]
  PIN perf_mispredicts[35] 
    ANTENNAPARTIALMETALAREA 7.3514 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 36.596 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 5.6004 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 31.28 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 30.8724 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 151.308 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via3 ;
  END perf_mispredicts[35]
  PIN perf_mispredicts[34] 
    ANTENNAPARTIALMETALAREA 8.82895 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 43.855 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met2 ; 
    ANTENNAMAXAREACAR 58.8721 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 286.165 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 4.7916 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 26.496 LAYER met3 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 66.4778 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 328.222 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_mispredicts[34]
  PIN perf_mispredicts[33] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 18.6564 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 99.496 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.63 LAYER met4 ; 
    ANTENNAMAXAREACAR 45.3343 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 232.26 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.460317 LAYER via4 ;
  END perf_mispredicts[33]
  PIN perf_mispredicts[32] 
    ANTENNAPARTIALMETALAREA 5.4838 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 27.258 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.5496 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 19.872 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 19.2828 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 91.673 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_mispredicts[32]
  PIN perf_mispredicts[31] 
    ANTENNAPARTIALMETALAREA 10.4208 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 51.835 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met2 ; 
    ANTENNAMAXAREACAR 35.4933 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 169.489 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.198413 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.7507 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.136 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 41.3149 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 201.523 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_mispredicts[31]
  PIN perf_mispredicts[30] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 7.9372 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 39.417 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 1.6467 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.248 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 9.23556 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 40.0582 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_mispredicts[30]
  PIN perf_mispredicts[29] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 14.5263 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 77.464 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met4 ; 
    ANTENNAMAXAREACAR 51.1086 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 266.647 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via4 ;
  END perf_mispredicts[29]
  PIN perf_mispredicts[28] 
    ANTENNAPARTIALMETALAREA 1.1046 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 5.362 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.883 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.176 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 9.6408 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 51.888 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met4 ; 
    ANTENNAMAXAREACAR 33.5904 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 171.536 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.481481 LAYER via4 ;
  END perf_mispredicts[28]
  PIN perf_mispredicts[27] 
    ANTENNAPARTIALMETALAREA 7.4802 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 37.24 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 6.2205 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 33.632 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.69375 LAYER met3 ; 
    ANTENNAMAXAREACAR 13.8832 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 62.6786 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_mispredicts[27]
  PIN perf_mispredicts[26] 
    ANTENNAPARTIALMETALAREA 7.1702 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 35.406 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met2 ; 
    ANTENNAMAXAREACAR 48.3403 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 232.521 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.08 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 4.8015 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 26.544 LAYER met3 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 55.9617 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 274.654 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via3 ;
  END perf_mispredicts[26]
  PIN perf_mispredicts[25] 
    ANTENNAPARTIALMETALAREA 6.482 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 32.249 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.7266 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 20.336 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 11.9222 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 54.8286 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_mispredicts[25]
  PIN perf_mispredicts[24] 
    ANTENNAPARTIALMETALAREA 8.2914 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 41.188 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met2 ; 
    ANTENNAMAXAREACAR 55.9854 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 271.613 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.7507 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.136 LAYER met3 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 60.3516 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 295.638 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_mispredicts[24]
  PIN perf_mispredicts[23] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 25.0833 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 133.768 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.63 LAYER met4 ; 
    ANTENNAMAXAREACAR 56.6802 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 296.435 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via4 ;
  END perf_mispredicts[23]
  PIN perf_mispredicts[22] 
    ANTENNAPARTIALMETALAREA 1.7808 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 8.743 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 1.573 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.856 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 20.6217 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 110.448 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.63 LAYER met4 ; 
    ANTENNAMAXAREACAR 46.9741 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 245.578 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via4 ;
  END perf_mispredicts[22]
  PIN perf_mispredicts[21] 
    ANTENNAPARTIALMETALAREA 0.5894 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.786 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.2509 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.808 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 19.1628 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 102.672 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.69375 LAYER met4 ; 
    ANTENNAMAXAREACAR 38.0556 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 196.375 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.258172 LAYER via4 ;
  END perf_mispredicts[21]
  PIN perf_mispredicts[20] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 17.2074 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 91.768 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.69375 LAYER met4 ; 
    ANTENNAMAXAREACAR 37.2179 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 190.476 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.454483 LAYER via4 ;
  END perf_mispredicts[20]
  PIN perf_mispredicts[19] 
    ANTENNAPARTIALMETALAREA 2.296 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 11.319 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 1.09 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.28 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 9.0198 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 48.576 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.63 LAYER met4 ; 
    ANTENNAMAXAREACAR 48.576 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 242.832 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.714286 LAYER via4 ;
  END perf_mispredicts[19]
  PIN perf_mispredicts[18] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 23.2203 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 123.832 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.63 LAYER met4 ; 
    ANTENNAMAXAREACAR 56.707 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 293.089 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via4 ;
  END perf_mispredicts[18]
  PIN perf_mispredicts[17] 
    ANTENNAPARTIALMETALAREA 10.8475 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 53.7425 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.63 LAYER met2 ; 
    ANTENNAMAXAREACAR 22.8154 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 106.226 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.349206 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.3268 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.88 LAYER met3 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 26.5087 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 126.671 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.349206 LAYER via3 ;
  END perf_mispredicts[17]
  PIN perf_mispredicts[16] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 19.0704 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 101.704 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.63 LAYER met4 ; 
    ANTENNAMAXAREACAR 62.1862 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 318.927 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.714286 LAYER via4 ;
  END perf_mispredicts[16]
  PIN perf_mispredicts[15] 
    ANTENNAPARTIALMETALAREA 8.5106 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 42.392 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.7507 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.136 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 11.0212 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 50.2603 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via3 ;
  END perf_mispredicts[15]
  PIN perf_mispredicts[14] 
    ANTENNAPARTIALMETALAREA 8.0338 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 39.9 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met2 ; 
    ANTENNAMAXAREACAR 27.9156 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 131.6 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.198413 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.7507 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.136 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 33.7371 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 163.634 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_mispredicts[14]
  PIN perf_mispredicts[13] 
    ANTENNAPARTIALMETALAREA 2.5214 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 12.446 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.255 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.808 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 7.9848 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 43.056 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met4 ; 
    ANTENNAMAXAREACAR 27.0137 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 136.902 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.481481 LAYER via4 ;
  END perf_mispredicts[13]
  PIN perf_mispredicts[12] 
    ANTENNAPARTIALMETALAREA 5.9856 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 29.659 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met2 ; 
    ANTENNAMAXAREACAR 15.699 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 70.745 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.1548 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 17.296 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 22.3759 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 107.35 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via3 ;
  END perf_mispredicts[12]
  PIN perf_mispredicts[11] 
    ANTENNAPARTIALMETALAREA 5.3535 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 26.4985 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.22125 LAYER met2 ; 
    ANTENNAMAXAREACAR 27.2574 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 129.986 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.282486 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 5.2446 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 28.432 LAYER met3 ;
    ANTENNAGATEAREA 0.69375 LAYER met3 ; 
    ANTENNAMAXAREACAR 34.8172 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 170.97 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_mispredicts[11]
  PIN perf_mispredicts[10] 
    ANTENNAPARTIALMETALAREA 2.0384 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 10.031 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 6.6054 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 36.16 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.69375 LAYER met3 ; 
    ANTENNAMAXAREACAR 13.5486 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 63.8971 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_mispredicts[10]
  PIN perf_mispredicts[9] 
    ANTENNAPARTIALMETALAREA 4.5546 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 22.288 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.63 LAYER met2 ; 
    ANTENNAMAXAREACAR 10.2606 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 43.3524 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.206349 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.6028 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 14.352 LAYER met3 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 14.3921 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 66.1333 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.206349 LAYER via3 ;
  END perf_mispredicts[9]
  PIN perf_mispredicts[8] 
    ANTENNAPARTIALMETALAREA 2.0062 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 9.87 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 4.9095 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 26.64 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 13.0973 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 61.1413 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_mispredicts[8]
  PIN perf_mispredicts[7] 
    ANTENNAPARTIALMETALAREA 4.1222 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 20.342 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met2 ; 
    ANTENNAMAXAREACAR 15.4978 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 69.5111 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.198413 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.7507 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.136 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 21.3194 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 101.545 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_mispredicts[7]
  PIN perf_mispredicts[6] 
    ANTENNAPARTIALMETALAREA 3.2038 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 15.75 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met2 ; 
    ANTENNAMAXAREACAR 12.5822 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 54.9333 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.198413 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.7167 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 20.288 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 20.4483 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 97.8709 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_mispredicts[6]
  PIN perf_mispredicts[5] 
    ANTENNAPARTIALMETALAREA 2.2316 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 10.997 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.1056 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 17.024 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 11.341 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 51.6042 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_mispredicts[5]
  PIN perf_mispredicts[4] 
    ANTENNAPARTIALMETALAREA 3.7512 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 18.487 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met2 ; 
    ANTENNAMAXAREACAR 14.32 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 63.6222 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.198413 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 4.1997 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 22.864 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 23.2083 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 112.012 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_mispredicts[4]
  PIN perf_mispredicts[3] 
    ANTENNAPARTIALMETALAREA 3.53 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 17.381 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met2 ; 
    ANTENNAMAXAREACAR 10.502 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 44.7598 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.7408 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.088 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 16.3026 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 76.6921 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via3 ;
  END perf_mispredicts[3]
  PIN perf_mispredicts[2] 
    ANTENNAPARTIALMETALAREA 2.5214 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 12.446 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.4846 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 13.712 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 10.854 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 48.2169 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_mispredicts[2]
  PIN perf_mispredicts[1] 
    ANTENNAPARTIALMETALAREA 0.8148 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 3.913 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 4.1016 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 22.816 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 18.0863 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 87.4328 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.312169 LAYER via3 ;
  END perf_mispredicts[1]
  PIN perf_mispredicts[0] 
    ANTENNAPARTIALMETALAREA 3.8406 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 18.816 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met2 ; 
    ANTENNAMAXAREACAR 9.84773 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 43.1048 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.132275 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.26895 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.832 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 10.4169 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 46.982 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.216931 LAYER via3 ;
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 100.928 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 538.752 LAYER met4 ;
    ANTENNAGATEAREA 0.7875 LAYER met4 ; 
    ANTENNAMAXAREACAR 144.821 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 766.826 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.325397 LAYER via4 ;
  END perf_mispredicts[0]
  PIN perf_load_use_stalls[63] 
    ANTENNAPARTIALMETALAREA 2.886 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 14.161 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met2 ; 
    ANTENNAMAXAREACAR 12.2078 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 50.3444 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.198413 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.9927 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 21.76 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 20.6579 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 96.3974 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_load_use_stalls[63]
  PIN perf_load_use_stalls[62] 
    ANTENNAPARTIALMETALAREA 3.4292 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 16.877 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met2 ; 
    ANTENNAMAXAREACAR 13.2978 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 58.5111 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.198413 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.8887 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.872 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 19.4114 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 92.1026 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_load_use_stalls[62]
  PIN perf_load_use_stalls[61] 
    ANTENNAPARTIALMETALAREA 4.0452 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 19.957 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met2 ; 
    ANTENNAMAXAREACAR 15.2533 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 68.2889 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.198413 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.5787 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 19.552 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 22.8273 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 109.669 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_load_use_stalls[61]
  PIN perf_load_use_stalls[60] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 2.4731 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 12.2045 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.1888 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.144 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 10.2112 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 45.8243 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via3 ;
  END perf_load_use_stalls[60]
  PIN perf_load_use_stalls[59] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 3.5223 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 17.3425 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.7507 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.136 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 10.9587 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 49.4529 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_load_use_stalls[59]
  PIN perf_load_use_stalls[58] 
    ANTENNAPARTIALMETALAREA 2.618 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 12.929 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.9721 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 16.312 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 11.1857 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 51.3339 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_load_use_stalls[58]
  PIN perf_load_use_stalls[57] 
    ANTENNAPARTIALMETALAREA 3.1206 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 15.281 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.08 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 4.4565 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 24.704 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 13.2229 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 63.6582 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_load_use_stalls[57]
  PIN perf_load_use_stalls[56] 
    ANTENNAPARTIALMETALAREA 3.0044 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 14.861 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.9622 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 16.264 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 10.6838 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 48.9513 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via3 ;
  END perf_load_use_stalls[56]
  PIN perf_load_use_stalls[55] 
    ANTENNAPARTIALMETALAREA 4.216 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 20.811 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met2 ; 
    ANTENNAMAXAREACAR 11.9539 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 52.019 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.1548 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 17.296 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 18.6307 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 88.6243 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via3 ;
  END perf_load_use_stalls[55]
  PIN perf_load_use_stalls[54] 
    ANTENNAPARTIALMETALAREA 3.1884 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 15.673 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met2 ; 
    ANTENNAMAXAREACAR 12.5333 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 54.6889 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.198413 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 4.2687 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 23.232 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 21.5676 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 103.857 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_load_use_stalls[54]
  PIN perf_load_use_stalls[53] 
    ANTENNAPARTIALMETALAREA 2.0384 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 10.031 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.0267 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 16.608 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 11.3494 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 52.0646 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via3 ;
  END perf_load_use_stalls[53]
  PIN perf_load_use_stalls[52] 
    ANTENNAPARTIALMETALAREA 2.7357 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 13.3945 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met2 ; 
    ANTENNAMAXAREACAR 20.4006 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 93.019 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 4.8207 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 26.176 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 30.6032 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 148.418 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_load_use_stalls[52]
  PIN perf_load_use_stalls[51] 
    ANTENNAPARTIALMETALAREA 4.0348 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 20.013 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 4.1115 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 22.864 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.69375 LAYER met3 ; 
    ANTENNAMAXAREACAR 12.9319 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 59.7984 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.312169 LAYER via3 ;
  END perf_load_use_stalls[51]
  PIN perf_load_use_stalls[50] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 6.1367 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 30.3065 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met2 ; 
    ANTENNAMAXAREACAR 41.7784 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 200.143 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.4648 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 13.616 LAYER met3 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 45.6908 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 221.756 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_load_use_stalls[50]
  PIN perf_load_use_stalls[49] 
    ANTENNAPARTIALMETALAREA 3.1332 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 15.505 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 4.3776 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 24.288 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 16.7963 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 80.3151 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.269841 LAYER via3 ;
  END perf_load_use_stalls[49]
  PIN perf_load_use_stalls[48] 
    ANTENNAPARTIALMETALAREA 6.3844 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 31.535 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met2 ; 
    ANTENNAMAXAREACAR 25.2478 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 118.334 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.37037 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.7507 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.136 LAYER met3 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 29.614 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 142.36 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_load_use_stalls[48]
  PIN perf_load_use_stalls[47] 
    ANTENNAPARTIALMETALAREA 2.5214 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 12.446 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.3367 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.928 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 9.97905 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 44.7577 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via3 ;
  END perf_load_use_stalls[47]
  PIN perf_load_use_stalls[46] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 3.3254 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 16.338 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.3268 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.88 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 9.85291 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 44.1302 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via3 ;
  END perf_load_use_stalls[46]
  PIN perf_load_use_stalls[45] 
    ANTENNAPARTIALMETALAREA 0.1127 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4025 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 4.3776 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 24.288 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 21.1014 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 102.474 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.312169 LAYER via3 ;
  END perf_load_use_stalls[45]
  PIN perf_load_use_stalls[44] 
    ANTENNAPARTIALMETALAREA 2.6824 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 13.251 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 4.8306 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 26.224 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 15.0168 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 71.8005 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_load_use_stalls[44]
  PIN perf_load_use_stalls[43] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 7.4118 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 36.456 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.53625 LAYER met2 ; 
    ANTENNAMAXAREACAR 16.8674 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 73.764 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.176287 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 1.4988 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.464 LAYER met3 ;
    ANTENNAGATEAREA 0.69375 LAYER met3 ; 
    ANTENNAMAXAREACAR 19.0278 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 85.9644 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_load_use_stalls[43]
  PIN perf_load_use_stalls[42] 
    ANTENNAPARTIALMETALAREA 5.7476 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 28.469 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met2 ; 
    ANTENNAMAXAREACAR 39.3079 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 188.476 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.6876 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 20.608 LAYER met3 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 45.1613 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 221.187 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_load_use_stalls[42]
  PIN perf_load_use_stalls[41] 
    ANTENNAPARTIALMETALAREA 2.0706 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 10.192 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.6759 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.048 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met3 ; 
    ANTENNAMAXAREACAR 8.74984 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 40.7587 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via3 ;
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 5.2938 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 28.704 LAYER met4 ;
    ANTENNAGATEAREA 0.63 LAYER met4 ; 
    ANTENNAMAXAREACAR 20.0945 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 99.1101 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via4 ;
  END perf_load_use_stalls[41]
  PIN perf_load_use_stalls[40] 
    ANTENNAPARTIALMETALAREA 4.5874 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 22.442 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.63 LAYER met2 ; 
    ANTENNAMAXAREACAR 13.5038 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 60.1048 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.349206 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 1.9128 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 10.672 LAYER met3 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 16.54 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 77.0444 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.349206 LAYER via3 ;
  END perf_load_use_stalls[40]
  PIN perf_load_use_stalls[39] 
    ANTENNAPARTIALMETALAREA 2.8818 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 14.14 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met2 ; 
    ANTENNAMAXAREACAR 12.1944 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 50.2778 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.198413 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 5.1066 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 27.696 LAYER met3 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 20.3002 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 94.2397 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_load_use_stalls[39]
  PIN perf_load_use_stalls[38] 
    ANTENNAPARTIALMETALAREA 3.0366 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 15.022 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 5.3634 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 29.536 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 18.9127 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 89.5905 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.650794 LAYER via3 ;
  END perf_load_use_stalls[38]
  PIN perf_load_use_stalls[37] 
    ANTENNAPARTIALMETALAREA 1.8774 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 9.226 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 6.1815 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 33.904 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.69375 LAYER met3 ; 
    ANTENNAMAXAREACAR 34.7905 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 171.153 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.564972 LAYER via3 ;
  END perf_load_use_stalls[37]
  PIN perf_load_use_stalls[36] 
    ANTENNAPARTIALMETALAREA 5.1286 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 25.256 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.22125 LAYER met2 ; 
    ANTENNAMAXAREACAR 25.4262 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 119.932 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.282486 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.7507 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.136 LAYER met3 ;
    ANTENNAGATEAREA 0.69375 LAYER met3 ; 
    ANTENNAMAXAREACAR 29.3912 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 141.75 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.282486 LAYER via3 ;
  END perf_load_use_stalls[36]
  PIN perf_load_use_stalls[35] 
    ANTENNAPARTIALMETALAREA 7.9315 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 39.1195 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met2 ; 
    ANTENNAMAXAREACAR 19.8321 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 90.7672 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.08 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.312169 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.2736 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 18.4 LAYER met3 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 25.0283 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 119.974 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_load_use_stalls[35]
  PIN perf_load_use_stalls[34] 
    ANTENNAPARTIALMETALAREA 3.3898 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 16.562 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met2 ; 
    ANTENNAMAXAREACAR 24.3378 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 112.876 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.2736 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 18.4 LAYER met3 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 29.534 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 142.083 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_load_use_stalls[34]
  PIN perf_load_use_stalls[33] 
    ANTENNAPARTIALMETALAREA 4.9998 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 24.612 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met2 ; 
    ANTENNAMAXAREACAR 16.561 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 74.9206 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.37037 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.9577 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 16.24 LAYER met3 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 21.2557 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 100.698 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_load_use_stalls[33]
  PIN perf_load_use_stalls[32] 
    ANTENNAPARTIALMETALAREA 4.7393 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 23.2015 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.63 LAYER met2 ; 
    ANTENNAMAXAREACAR 14.3252 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 63.7548 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.349206 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.7408 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.088 LAYER met3 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 18.6757 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 87.704 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.349206 LAYER via3 ;
  END perf_load_use_stalls[32]
  PIN perf_load_use_stalls[31] 
    ANTENNAPARTIALMETALAREA 1.9418 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 9.548 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.7507 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.136 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 13.5073 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 62.9196 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via3 ;
  END perf_load_use_stalls[31]
  PIN perf_load_use_stalls[30] 
    ANTENNAPARTIALMETALAREA 4.0831 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 20.2545 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met2 ; 
    ANTENNAMAXAREACAR 28.9556 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 136.575 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 5.1657 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 28.016 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 39.8883 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 195.868 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_load_use_stalls[30]
  PIN perf_load_use_stalls[29] 
    ANTENNAPARTIALMETALAREA 5.6185 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 27.5975 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met2 ; 
    ANTENNAMAXAREACAR 14.9221 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 66.382 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.3268 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.88 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 19.8466 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 93.6413 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via3 ;
  END perf_load_use_stalls[29]
  PIN perf_load_use_stalls[28] 
    ANTENNAPARTIALMETALAREA 5.378 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 26.621 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met2 ; 
    ANTENNAMAXAREACAR 19.4844 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 89.4444 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.198413 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 5.0967 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 27.648 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 30.2711 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 147.959 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_load_use_stalls[28]
  PIN perf_load_use_stalls[27] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 9.271 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 45.752 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.53625 LAYER met2 ; 
    ANTENNAMAXAREACAR 20.3345 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 91.0992 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.176287 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 1.3608 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.728 LAYER met3 ;
    ANTENNAGATEAREA 0.69375 LAYER met3 ; 
    ANTENNAMAXAREACAR 22.296 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 102.239 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_load_use_stalls[27]
  PIN perf_load_use_stalls[26] 
    ANTENNAPARTIALMETALAREA 6.482 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 32.249 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 5.5605 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 30.592 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 14.931 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 70.9704 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_load_use_stalls[26]
  PIN perf_load_use_stalls[25] 
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 10.9974 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 58.648 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.63 LAYER met4 ; 
    ANTENNAMAXAREACAR 33.2388 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 167.714 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.460317 LAYER via4 ;
  END perf_load_use_stalls[25]
  PIN perf_load_use_stalls[24] 
    ANTENNAPARTIALMETALAREA 8.0603 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 39.7635 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met2 ; 
    ANTENNAMAXAREACAR 20.0899 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 92.1302 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.08 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.312169 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 6.1716 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 33.856 LAYER met3 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 29.8861 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 145.87 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_load_use_stalls[24]
  PIN perf_load_use_stalls[23] 
    ANTENNAPARTIALMETALAREA 6.5848 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 32.655 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met2 ; 
    ANTENNAMAXAREACAR 23.95 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 109.056 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.198413 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 5.9346 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 32.112 LAYER met3 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 33.37 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 160.027 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_load_use_stalls[23]
  PIN perf_load_use_stalls[22] 
    ANTENNAPARTIALMETALAREA 6.2432 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 30.947 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met2 ; 
    ANTENNAMAXAREACAR 16.2442 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 73.4709 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.7408 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.088 LAYER met3 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 20.5947 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 97.4201 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_load_use_stalls[22]
  PIN perf_load_use_stalls[21] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 6.0989 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 30.1175 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.22125 LAYER met2 ; 
    ANTENNAMAXAREACAR 29.5607 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 141.503 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.282486 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.6127 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 14.4 LAYER met3 ;
    ANTENNAGATEAREA 0.69375 LAYER met3 ; 
    ANTENNAMAXAREACAR 33.3267 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 162.26 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_load_use_stalls[21]
  PIN perf_load_use_stalls[20] 
    ANTENNAPARTIALMETALAREA 4.4534 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 22.106 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 5.9445 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 32.16 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.69375 LAYER met3 ; 
    ANTENNAMAXAREACAR 13.4642 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 63.1679 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_load_use_stalls[20]
  PIN perf_load_use_stalls[19] 
    ANTENNAPARTIALMETALAREA 7.3744 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 36.603 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met2 ; 
    ANTENNAMAXAREACAR 50.1632 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 242.502 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.7167 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 20.288 LAYER met3 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 56.0627 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 274.705 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_load_use_stalls[19]
  PIN perf_load_use_stalls[18] 
    ANTENNAPARTIALMETALAREA 8.114 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 40.075 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met2 ; 
    ANTENNAMAXAREACAR 19.9877 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 92.5355 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 4.9587 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 26.912 LAYER met3 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 27.8587 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 135.253 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_load_use_stalls[18]
  PIN perf_load_use_stalls[17] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 8.8465 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 43.8305 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met2 ; 
    ANTENNAMAXAREACAR 59.9584 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 290.632 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.539683 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.1548 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 17.296 LAYER met3 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 64.966 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 318.086 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.539683 LAYER via3 ;
  END perf_load_use_stalls[17]
  PIN perf_load_use_stalls[16] 
    ANTENNAPARTIALMETALAREA 0.203 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.854 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAPARTIALMETALAREA 0.26895 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.832 LAYER met3 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via3 ;
    ANTENNADIFFAREA 0.50085 LAYER met4 ; 
    ANTENNAPARTIALMETALAREA 8.6058 LAYER met4 ;
    ANTENNAPARTIALMETALSIDEAREA 46.368 LAYER met4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.63 LAYER met4 ; 
    ANTENNAMAXAREACAR 33.4844 LAYER met4 ;
    ANTENNAMAXSIDEAREACAR 167.184 LAYER met4 ;
    ANTENNAMAXCUTCAR 0.714286 LAYER via4 ;
  END perf_load_use_stalls[16]
  PIN perf_load_use_stalls[15] 
    ANTENNAPARTIALMETALAREA 2.296 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 11.319 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.8596 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 16.192 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 16.5953 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 78.873 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.312169 LAYER via3 ;
  END perf_load_use_stalls[15]
  PIN perf_load_use_stalls[14] 
    ANTENNAPARTIALMETALAREA 5.7154 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 28.308 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met2 ; 
    ANTENNAMAXAREACAR 20.5556 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 94.8 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.198413 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.4407 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 18.816 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 27.8375 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 134.622 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_load_use_stalls[14]
  PIN perf_load_use_stalls[13] 
    ANTENNAPARTIALMETALAREA 5.7062 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 28.154 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met2 ; 
    ANTENNAMAXAREACAR 15.1077 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 67.5598 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.1888 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.144 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 19.7401 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 93.2614 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via3 ;
  END perf_load_use_stalls[13]
  PIN perf_load_use_stalls[12] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 7.0741 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 35.1015 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.1647 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 17.344 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 11.8111 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 54.6069 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_load_use_stalls[12]
  PIN perf_load_use_stalls[11] 
    ANTENNAPARTIALMETALAREA 7.6409 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 37.8175 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.37875 LAYER met2 ; 
    ANTENNAMAXAREACAR 24.9812 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 118.8 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.309 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.8547 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 21.024 LAYER met3 ;
    ANTENNAGATEAREA 0.69375 LAYER met3 ; 
    ANTENNAMAXAREACAR 30.5375 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 149.104 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.309 LAYER via3 ;
  END perf_load_use_stalls[11]
  PIN perf_load_use_stalls[10] 
    ANTENNAPARTIALMETALAREA 8.1465 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 40.3025 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met2 ; 
    ANTENNAMAXAREACAR 28.2733 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 132.878 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.08 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.325397 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.7216 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.456 LAYER met3 ;
    ANTENNAGATEAREA 0.69375 LAYER met3 ; 
    ANTENNAMAXAREACAR 32.1964 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 155.157 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.325397 LAYER via3 ;
  END perf_load_use_stalls[10]
  PIN perf_load_use_stalls[9] 
    ANTENNAPARTIALMETALAREA 9.4818 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 46.914 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met2 ; 
    ANTENNAMAXAREACAR 23.4089 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 109.39 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 4.5447 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 24.704 LAYER met3 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 30.6227 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 148.603 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_load_use_stalls[9]
  PIN perf_load_use_stalls[8] 
    ANTENNAPARTIALMETALAREA 7.0524 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 34.993 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1575 LAYER met2 ; 
    ANTENNAMAXAREACAR 47.5924 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 229.898 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 4.5156 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 25.024 LAYER met3 ;
    ANTENNAGATEAREA 0.63 LAYER met3 ; 
    ANTENNAMAXAREACAR 54.76 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 269.619 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_load_use_stalls[8]
  PIN perf_load_use_stalls[7] 
    ANTENNAPARTIALMETALAREA 5.5804 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 27.741 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 5.6586 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 30.64 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 16.0032 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 76.6212 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_load_use_stalls[7]
  PIN perf_load_use_stalls[6] 
    ANTENNADIFFAREA 0.50085 LAYER met2 ; 
    ANTENNAPARTIALMETALAREA 5.1086 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 25.249 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.7507 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.136 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 10.4105 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 47.3116 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_load_use_stalls[6]
  PIN perf_load_use_stalls[5] 
    ANTENNAPARTIALMETALAREA 3.1976 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 15.827 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 5.151 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 28.408 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 17.4038 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 84.4561 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_load_use_stalls[5]
  PIN perf_load_use_stalls[4] 
    ANTENNAPARTIALMETALAREA 3.2107 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 15.6765 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met2 ; 
    ANTENNAMAXAREACAR 9.82624 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 41.1524 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.6028 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 14.352 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 15.3348 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 71.527 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via3 ;
  END perf_load_use_stalls[4]
  PIN perf_load_use_stalls[3] 
    ANTENNAPARTIALMETALAREA 3.9534 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 19.39 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met2 ; 
    ANTENNAMAXAREACAR 11.3981 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 49.0116 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.7408 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.088 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 17.1987 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 80.9439 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.227513 LAYER via3 ;
  END perf_load_use_stalls[3]
  PIN perf_load_use_stalls[2] 
    ANTENNAPARTIALMETALAREA 3.53 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 17.381 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.315 LAYER met2 ; 
    ANTENNAMAXAREACAR 13.6178 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 60.1111 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.198413 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 2.7507 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.136 LAYER met3 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 19.4394 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 92.145 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_load_use_stalls[2]
  PIN perf_load_use_stalls[1] 
    ANTENNAPARTIALMETALAREA 2.0384 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 10.031 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 1.8537 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 10.352 LAYER met3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met3 ; 
    ANTENNAMAXAREACAR 8.3473 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 36.0201 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.396825 LAYER via3 ;
  END perf_load_use_stalls[1]
  PIN perf_load_use_stalls[0] 
    ANTENNAPARTIALMETALAREA 8.3164 LAYER met2 ;
    ANTENNAPARTIALMETALSIDEAREA 41.195 LAYER met2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4725 LAYER met2 ; 
    ANTENNAMAXAREACAR 19.3203 LAYER met2 ;
    ANTENNAMAXSIDEAREACAR 90.4677 LAYER met2 ;
    ANTENNAPARTIALCUTAREA 0.04 LAYER via2 ;
    ANTENNAMAXCUTCAR 0.132275 LAYER via2 ;
    ANTENNADIFFAREA 0.50085 LAYER met3 ; 
    ANTENNAPARTIALMETALAREA 3.1647 LAYER met3 ;
    ANTENNAPARTIALMETALSIDEAREA 17.344 LAYER met3 ;
    ANTENNAGATEAREA 0.7875 LAYER met3 ; 
    ANTENNAMAXAREACAR 23.339 LAYER met3 ;
    ANTENNAMAXSIDEAREACAR 112.492 LAYER met3 ;
    ANTENNAMAXCUTCAR 0.198413 LAYER via3 ;
  END perf_load_use_stalls[0]
END riscv_core

END LIBRARY
